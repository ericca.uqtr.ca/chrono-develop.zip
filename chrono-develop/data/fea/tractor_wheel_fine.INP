** Output from COS2ABQ translator version 2010
*HEADING

** PARTS
**
*PART,NAME=PART1
*NODE, NSET=NSET1
1,-.1104936004,0.5751289129,-.2582403719
2,-.3987055644E-01,0.6298547983,-.6404489279E-01
3,0.7171866600E-03,0.6292254329,-.7346724719E-01
4,0.2380023361E-03,0.6208315492,-.1260571033
5,-.9543947130E-01,0.6156882048,-.1391710490
6,-.9543947130E-01,0.5821447968,-.2440245003
7,-.2094821185,0.5664156675,-.2388503253
8,-.2403514534,0.5334894657,-.2497312725
9,-.2545000613,0.4996226132,-.2643168569
10,-.2546792626,0.4771024883,-.3022801876
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG1
1,6661,6662,3718,3738,29091,29092,29093,29094,29095,14660
2,6661,6069,6663,6662,29096,29097,29098,29091,29099,29100
3,6661,6664,3703,6665,29101,29102,29103,29104,29105,29106
4,6661,6172,6664,6665,29107,29108,29101,29104,29109,29105
5,6666,72,6667,6668,29110,29111,29112,29113,29114,29115
6,6666,78,6669,6670,29116,29117,29118,29119,29120,29121
7,6671,680,6670,6672,29122,29123,29124,29125,29126,29127
8,6673,6674,2928,6666,29128,29129,29130,29131,29132,29133
9,6666,6669,78,6675,29118,29117,29116,29134,29135,29136
10,6666,6676,78,6677,29137,29138,29116,29139,29140,29141
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*ORIENTATION,NAME=RECT1,DEFINITION=COORDINATES,SYSTEM=RECTANGULAR
1.0,0.0,0.0,0.0,1.0,0.0
0.0,0.0,0.0
*SOLID SECTION,ELSET=PART1_EG1,MATERIAL=MAT1, ORIENT=RECT1
*END PART
** ASSEMBLY
*ASSEMBLY, NAME=ASSEMBLY
*INSTANCE, NAME=PART1-1, PART=PART1
*END INSTANCE
*NSET,NSET=BC_SURF,INSTANCE=PART1-1
751,752,753,754,755,756,757,758,759,760,761,762,763,764,765,766,
767,768,769,770,771,772,773,774,775,776,777,778,779,780,781,782,
783,784,785,786,787,788,789,790,791,792,793,794,795,796,797,798,
799,800,801,802,803,804,805,806,807,808,809,810,811,812,813,814,
815,816,817,818,819,820,821,822,823,824,825,826,827,828,829,830,
831,832,833,834,835,836,837,838,839,840,841,842,843,844,845,846,
847,848,849,850,851,852,853,854,855,856,857,858,859,860,861,862,
863,864,865,866,867,868,869,870,871,872,873,874,875,876,877,878,
879,880,881,882,883,884,885,886,887,888,889,890,891,892,893,894,
895,896,897,898,899,900,901,902,903,904,905,906,907,908,909,910,
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*NSET,NSET=BC_RIMTIRE,INSTANCE=PART1-1
2140,2141,2142,2143,2144,2145,2146,2147,2148,2149,2150,2151,2152,2153,2154,2155,
2156,2157,2158,2159,2160,2161,2162,2163,2164,2165,2166,2167,2168,2169,2170,2171,
2172,2173,2174,2175,2176,2177,2178,3323,3324,3325,3326,3327,3328,3329,3330,3331,
3332,3333,3334,3335,3336,3337,3338,3339,3340,3341,3342,3343,3344,3345,3346,3347,
3348,3349,3350,3351,3352,3353,3354,3355,3356,3357,3358,3359,3360,3361,3362,3363,
3364,3365,3366,3367,3368,3369,3370,3371,3372,3373,3374,3375,3376,3377,3378,3379,
3380,3381,3382,3383,3384,3385,3386,3387,3388,3389,3390,3391,3392,3393,3394,3395,
3396,3397,3398,3399,3400,3401,3402,3403,3404,3405,3406,3407,3408,3409,3410,3411,
3412,12059,12060,12061,12062,12063,12064,12065,12066,12067,12068,12069,12070,12071,12072,12073,
12074,12075,12076,12077,12078,12079,12080,12081,12082,12083,12084,12085,12086,12087,12088,12089,
12090,12091,12092,12093,12094,12095,12096,12097,12098,12099,12100,12101,12102,12103,12104,12105,
12106,12107,12108,12109,12110,12111,12112,12113,12114,12115,12116,12117,12118,12119,12120,12121,
12122,12123,12124,12125,12126,12127,12128,12129,12130,12131,12823,12824,12825,12826,12827,12828,
12829,12830,12831,12832,12833,12834,12835,12836,12837,12838,12839,12840,12841,12842,12843,12844,
12845,12846,12847,12848,12849,12850,12851,12852,12853,12854,12855,12856,12857,12858,12859,12860,
12861,12862,12863,12864,12865,12866,12867,12868,12869,12870,12871,12872,12873,12874,12875,12876,
12877,12878,12879,12880,12881,12882,12883,12884,12885,12886,12887,12888,12889,12890,12891,12892,
12893,12894,12895,12896,12897,12898,12899,12900,12901,12902,12903,12904,12905,12906,12907,12908,
12909,12910,12911,12912,25799,25800,25801,25802,25803,25804,25805,25806,25807,25808,25809,25810,
25811,25812,25813,25814,25815,25816,25817,25818,25819,25820,25821,25822,25823,25824,25825,25826,
25827,25828,25829,25830,25831,25832,25833,25834,25835,25836,25837,25838,25839,25840,25841,25842,
25843,25844,25845,25846,25847,25848,25849,25850,25851,25852,25853,25854,25855,25856,25857,25858,
25859,25860,25861,25862,25863,25864,25865,25866,25867,25868,25869,25870,25871,25872,25873,25874,
25875,25876,25877,25878,25879,25880,25881,25882,25883,25884,25885,25886,25887,25888,25889,25890,
25891,25892,25893,25894,25895,25896,25897,25898,25899,25900,25901,25902,25903,25904,25905,25906,
25907,25908,25909,25910,25911,25912,25913,25914,25915,25916,25917,25918,25919,25920,25921,25922,
25923,25924,25925,25926,25927,25928,25929,25930,25931,25932,25933,25934,25935,25936,25937,25938,
25939,25940,25941,25942,25943,25944,25945,25946,25947,25948,25949,25950,25951,25952,25953,25954,
25955,25956,25957,25958,25959,25960,25961,25962,25963,25964,25965,25966,25967,25968,25969,
*END ASSEMBLY
*MATERIAL,NAME=MAT1
*ELASTIC
0.610000E+07,0.490000E+00,
*PLASTIC
0.92374E+07,0.0000,0.0000
*EXPANSION
0.670000E-03,
*DENSITY
0.100000E+04,
*CONDUCTIVITY
0.140000E+00,
*STEP,SOLVER=ITERATIVE
LOAD CASE NUMBER 1
*STATIC
*BOUNDARY
ASSEMBLY.BC_SURF,1,1
ASSEMBLY.BC_SURF,2,2
ASSEMBLY.BC_SURF,3,3
ASSEMBLY.BC_RIMTIRE,3,3
*END STEP
