  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           826                             0                             0                             0                             0                             0                             0
  0.2855786811015745030862E-16  0.8350873084007624791436E-01  0.9336853795239663522665E+00 -0.6113906976003831256862E-16 -0.5517350488583697143419E-01 -0.9984767820828946982559E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           827                             0                             0                             0                             0                             0                             0
 -0.5845358770285401933675E-01  0.8350873084007624791436E-01  0.9300077915038592601960E+00  0.1251423237373304742093E+00 -0.5517350488583696449529E-01 -0.9906034944256120189365E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           828                             0                             0                             0                             0                             0                             0
 -0.1159853274091531133427E+00  0.8350873084007624791436E-01  0.9190330252034997204902E+00  0.2483110782729222310028E+00 -0.5517350488583697837308E-01 -0.9671077979033935179132E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           829                             0                             0                             0                             0                             0                             0
 -0.1716879092159339093016E+00  0.8350873084007624791436E-01  0.9009341592434518819488E+00  0.3675638187703023085362E+00 -0.5517350488583697143419E-01 -0.9283602336860431458732E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           830                             0                             0                             0                             0                             0                             0
 -0.2246828701329937894027E+00  0.8350873084007624791436E-01  0.8759966235516443155973E+00  0.4810198582736923689218E+00 -0.5517350488583697143419E-01 -0.8749718740079416301469E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           831                             0                             0                             0                             0                             0                             0
 -0.2741344479690152047269E+00  0.8350873084007624791436E-01  0.8446136979628986463098E+00  0.5868899272647705167572E+00 -0.5517350488583697837308E-01 -0.8077846851938731420617E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           832                             0                             0                             0                             0                             0                             0
 -0.3192627618005841605431E+00  0.8350873084007624791436E-01  0.8072803099609999755160E+00  0.6835043915118352853000E+00 -0.5517350488583697143419E-01 -0.7278582493471158487708E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           833                             0                             0                             0                             0                             0                             0
 -0.3593561111602285862432E+00  0.8350873084007624791436E-01  0.7645852293766234319961E+00  0.7693395831990263999955E+00 -0.5517350488583697143419E-01 -0.6364530541067116020670E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           834                             0                             0                             0                             0                             0                             0
 -0.3937821999779406723086E+00  0.8350873084007624791436E-01  0.7172017831353896255564E+00  0.8430418300779782825316E+00 -0.5517350488583697143419E-01 -0.5350106140044190716765E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           835                             0                             0                             0                             0                             0                             0
 -0.4219981082679165051985E+00  0.8350873084007624791436E-01  0.6658772364900217288763E+00  0.9034488036878219885395E+00 -0.5517350488583697143419E-01 -0.4251307369194277652191E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           836                             0                             0                             0                             0                             0                             0
 -0.4435588543010565154567E+00  0.8350873084007624791436E-01  0.6114210082009152724680E+00  0.9496078499693529906267E+00 -0.5517350488583697143419E-01 -0.3085462941524255708892E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           837                             0                             0                             0                             0                             0                             0
 -0.4581244122326530443523E+00  0.8350873084007624791436E-01  0.5546919055187629066239E+00  0.9807910131886347082641E+00 -0.5517350488583697837308E-01 -0.1870958920100168620948E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           838                             0                             0                             0                             0                             0                             0
 -0.4654650745130819999851E+00  0.8350873084007624791436E-01  0.4965845802811857390147E+00  0.9965065162337796156322E+00 -0.5517350488583697143419E-01 -0.6269487588494174201692E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           839                             0                             0                             0                             0                             0                             0
 -0.4654650745130819999851E+00  0.8350873084007624791436E-01  0.4380154197188143583297E+00  0.9965065162337796156322E+00 -0.5517350488583697143419E-01  0.6269487588494150609453E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           840                             0                             0                             0                             0                             0                             0
 -0.4581244122326530443523E+00  0.8350873084007624791436E-01  0.3799080944812371907204E+00  0.9807910131886347082641E+00 -0.5517350488583697143419E-01  0.1870958920100166122946E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           841                             0                             0                             0                             0                             0                             0
 -0.4435588543010565709679E+00  0.8350873084007624791436E-01  0.3231789917990848248763E+00  0.9496078499693531016490E+00 -0.5517350488583697143419E-01  0.3085462941524253488446E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           842                             0                             0                             0                             0                             0                             0
 -0.4219981082679165607097E+00  0.8350873084007624791436E-01  0.2687227635099783684680E+00  0.9034488036878220995618E+00 -0.5517350488583697837308E-01  0.4251307369194275431745E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           843                             0                             0                             0                             0                             0                             0
 -0.3937821999779405057751E+00  0.8350873084007624791436E-01  0.2173982168646100554543E+00  0.8430418300779779494647E+00 -0.5517350488583697143419E-01  0.5350106140044196267880E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           844                             0                             0                             0                             0                             0                             0
 -0.3593561111602286972655E+00  0.8350873084007624791436E-01  0.1700147706233766653483E+00  0.7693395831990266220402E+00 -0.5517350488583697837308E-01  0.6364530541067113800224E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           845                             0                             0                             0                             0                             0                             0
 -0.3192627618005844380988E+00  0.8350873084007624791436E-01  0.1273196900390001773395E+00  0.6835043915118358404115E+00 -0.5517350488583697837308E-01  0.7278582493471154046816E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           846                             0                             0                             0                             0                             0                             0
 -0.2741344479690154822826E+00  0.8350873084007624791436E-01  0.8998630203710156205688E-01  0.5868899272647710718687E+00 -0.5517350488583697143419E-01  0.8077846851938726979725E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           847                             0                             0                             0                             0                             0                             0
 -0.2246828701329940669584E+00  0.8350873084007624791436E-01  0.5860337644835589276937E-01  0.4810198582736929795445E+00 -0.5517350488583696449529E-01  0.8749718740079412970800E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           848                             0                             0                             0                             0                             0                             0
 -0.1716879092159338260348E+00  0.8350873084007624791436E-01  0.3366584075654804886213E-01  0.3675638187703021420027E+00 -0.5517350488583697143419E-01  0.9283602336860432568955E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           849                             0                             0                             0                             0                             0                             0
 -0.1159853274091534186541E+00  0.8350873084007624791436E-01  0.1556697479650032134302E-01  0.2483110782729228971366E+00 -0.5517350488583696449529E-01  0.9671077979033932958686E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           850                             0                             0                             0                             0                             0                             0
 -0.5845358770285412342016E-01  0.8350873084007624791436E-01  0.4592208496140726126100E-02  0.1251423237373306962539E+00 -0.5517350488583696449529E-01  0.9906034944256120189365E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           851                             0                             0                             0                             0                             0                             0
  0.2829753959675105425265E-16  0.1043862266863211235579E+00  0.5166107738934999638047E-02 -0.5673639514979832001175E-16 -0.3761084501259890355840E+00  0.9265756492288292900383E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           852                             0                             0                             0                             0                             0                             0
  0.5792073505673708128105E-01  0.1043862266863211235579E+00  0.8810171512116382608326E-02 -0.1161307222597937199859E+00 -0.3761084501259890910951E+00  0.9192693234799284018877E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           853                             0                             0                             0                             0                             0                             0
  0.1149280255214593926549E+00  0.1043862266863211235579E+00  0.1968489376909943189276E-01 -0.2304299936564195849797E+00 -0.3761084501259889800728E+00  0.8974655713548731483797E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           854                             0                             0                             0                             0                             0                             0
  0.1701228323690337773666E+00  0.1043862266863211235579E+00  0.3761877364364724085632E-01 -0.3410952464008779605464E+00 -0.3761084501259890355840E+00  0.8615082510496059331473E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           855                             0                             0                             0                             0                             0                             0
  0.2226347005236943288331E+00  0.1043862266863211235579E+00  0.6232898313695756087327E-01 -0.4463812233491707415212E+00 -0.3761084501259890910951E+00  0.8119644309852028785102E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           856                             0                             0                             0                             0                             0                             0
  0.2716354864555726722486E+00  0.1043862266863211235579E+00  0.9342582748415739768433E-01 -0.5446275017500294968187E+00 -0.3761084501259890355840E+00  0.7496154468001230419816E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           857                             0                             0                             0                             0                             0                             0
  0.3163524184988724119449E+00  0.1043862266863211235579E+00  0.1304188908735369745173E+00 -0.6342846791035908760037E+00 -0.3761084501259890355840E+00  0.6754445792204429865890E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           858                             0                             0                             0                             0                             0                             0
  0.3560802839226703819797E+00  0.1043862266863211235579E+00  0.1727247705968608659788E+00 -0.7139388081643874839344E+00 -0.3761084501259890355840E+00  0.5906215471354226975720E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           859                             0                             0                             0                             0                             0                             0
  0.3901925505569567853570E+00  0.1043862266863211235579E+00  0.2196762776585846344002E+00 -0.7823336957340603081690E+00 -0.3761084501259890910951E+00  0.4964840604318665473471E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           860                             0                             0                             0                             0                             0                             0
  0.4181512475792285021825E+00  0.1043862266863211235579E+00  0.2705329587448741524014E+00 -0.8383907135785100273040E+00 -0.3761084501259890355840E+00  0.3945167235100981439899E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           861                             0                             0                             0                             0                             0                             0
  0.4395154496357283058217E+00  0.1043862266863211235579E+00  0.3244927736146899222014E+00 -0.8812258090394905485354E+00 -0.3761084501259890355840E+00  0.2863276221857083969624E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           862                             0                             0                             0                             0                             0                             0
  0.4539482304976695803411E+00  0.1043862266863211235579E+00  0.3807047437535039935419E+00 -0.9101634470731365667007E+00 -0.3761084501259890910951E+00  0.1736229632156193192216E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           863                             0                             0                             0                             0                             0                             0
  0.4612219765891339973152E+00  0.1043862266863211235579E+00  0.4382823728128239504365E+00 -0.9247472638411502465772E+00 -0.3761084501259889800728E+00  0.5818016639828910152588E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           864                             0                             0                             0                             0                             0                             0
  0.4612219765891339973152E+00  0.1043862266863211235579E+00  0.4963176271871760358856E+00 -0.9247472638411502465772E+00 -0.3761084501259889800728E+00 -0.5818016639828910152588E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           865                             0                             0                             0                             0                             0                             0
  0.4539482304976695803411E+00  0.1043862266863211235579E+00  0.5538952562464960482913E+00 -0.9101634470731365667007E+00 -0.3761084501259890910951E+00 -0.1736229632156193192216E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           866                             0                             0                             0                             0                             0                             0
  0.4395154496357283613328E+00  0.1043862266863211235579E+00  0.6101072263853100086095E+00 -0.8812258090394906595577E+00 -0.3761084501259890355840E+00 -0.2863276221857081749178E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           867                             0                             0                             0                             0                             0                             0
  0.4181512475792284466714E+00  0.1043862266863211235579E+00  0.6640670412551259449430E+00 -0.8383907135785099162817E+00 -0.3761084501259890355840E+00 -0.3945167235100983105234E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           868                             0                             0                             0                             0                             0                             0
  0.3901925505569566188235E+00  0.1043862266863211235579E+00  0.7149237223414155462109E+00 -0.7823336957340599751021E+00 -0.3761084501259890355840E+00 -0.4964840604318668249029E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           869                             0                             0                             0                             0                             0                             0
  0.3560802839226703819797E+00  0.1043862266863211235579E+00  0.7618752294031392313656E+00 -0.7139388081643873729121E+00 -0.3761084501259889245617E+00 -0.5906215471354228085943E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           870                             0                             0                             0                             0                             0                             0
  0.3163524184988725229672E+00  0.1043862266863211235579E+00  0.8041811091264629007824E+00 -0.6342846791035909870260E+00 -0.3761084501259890355840E+00 -0.6754445792204427645444E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           871                             0                             0                             0                             0                             0                             0
  0.2716354864555726722486E+00  0.1043862266863211235579E+00  0.8411741725158425886377E+00 -0.5446275017500294968187E+00 -0.3761084501259890355840E+00 -0.7496154468001230419816E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           872                             0                             0                             0                             0                             0                             0
  0.2226347005236942455664E+00  0.1043862266863211235579E+00  0.8722710168630424254488E+00 -0.4463812233491705749877E+00 -0.3761084501259890910951E+00 -0.8119644309852029895325E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           873                             0                             0                             0                             0                             0                             0
  0.1701228323690337773666E+00  0.1043862266863211235579E+00  0.8969812263563528009769E+00 -0.3410952464008779605464E+00 -0.3761084501259890355840E+00 -0.8615082510496059331473E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           874                             0                             0                             0                             0                             0                             0
  0.1149280255214596008217E+00  0.1043862266863211235579E+00  0.9149151062309004434070E+00 -0.2304299936564200013134E+00 -0.3761084501259889800728E+00 -0.8974655713548730373574E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           875                             0                             0                             0                             0                             0                             0
  0.5792073505673717842557E-01  0.1043862266863211235579E+00  0.9257898284878836037137E+00 -0.1161307222597939281528E+00 -0.3761084501259890355840E+00 -0.9192693234799282908654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           876                             0                             0                             0                             0                             0                             0
  0.2829753959675105425265E-16  0.1043862266863211235579E+00  0.9294338922610649866840E+00 -0.5673639514979832001175E-16 -0.3761084501259890355840E+00 -0.9265756492288292900383E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           877                             0                             0                             0                             0                             0                             0
 -0.5792073505673712985331E-01  0.1043862266863211235579E+00  0.9257898284878836037137E+00  0.1161307222597938171305E+00 -0.3761084501259889800728E+00 -0.9192693234799282908654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           878                             0                             0                             0                             0                             0                             0
 -0.1149280255214593371438E+00  0.1043862266863211235579E+00  0.9149151062309006654516E+00  0.2304299936564194739574E+00 -0.3761084501259890355840E+00 -0.8974655713548732594020E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           879                             0                             0                             0                             0                             0                             0
 -0.1701228323690337218554E+00  0.1043862266863211235579E+00  0.8969812263563528009769E+00  0.3410952464008778495241E+00 -0.3761084501259890355840E+00 -0.8615082510496059331473E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           880                             0                             0                             0                             0                             0                             0
 -0.2226347005236943843443E+00  0.1043862266863211235579E+00  0.8722710168630423144265E+00  0.4463812233491707970323E+00 -0.3761084501259890355840E+00 -0.8119644309852027674879E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           881                             0                             0                             0                             0                             0                             0
 -0.2716354864555725057151E+00  0.1043862266863211235579E+00  0.8411741725158428106823E+00  0.5446275017500290527295E+00 -0.3761084501259890910951E+00 -0.7496154468001233750485E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           882                             0                             0                             0                             0                             0                             0
 -0.3163524184988723009226E+00  0.1043862266863211235579E+00  0.8041811091264631228270E+00  0.6342846791035906539591E+00 -0.3761084501259890355840E+00 -0.6754445792204432086336E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           883                             0                             0                             0                             0                             0                             0
 -0.3560802839226704374909E+00  0.1043862266863211235579E+00  0.7618752294031390093210E+00  0.7139388081643875949567E+00 -0.3761084501259890355840E+00 -0.5906215471354225865497E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           884                             0                             0                             0                             0                             0                             0
 -0.3901925505569568408681E+00  0.1043862266863211235579E+00  0.7149237223414152131440E+00  0.7823336957340604191913E+00 -0.3761084501259890355840E+00 -0.4964840604318662142802E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           885                             0                             0                             0                             0                             0                             0
 -0.4181512475792286132048E+00  0.1043862266863211235579E+00  0.6640670412551256118761E+00  0.8383907135785102493486E+00 -0.3761084501259890355840E+00 -0.3945167235100976999007E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           886                             0                             0                             0                             0                             0                             0
 -0.4395154496357283058217E+00  0.1043862266863211235579E+00  0.6101072263853101196318E+00  0.8812258090394905485354E+00 -0.3761084501259890355840E+00 -0.2863276221857084524736E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           887                             0                             0                             0                             0                             0                             0
 -0.4539482304976695803411E+00  0.1043862266863211235579E+00  0.5538952562464959372690E+00  0.9101634470731365667007E+00 -0.3761084501259890910951E+00 -0.1736229632156192359549E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           888                             0                             0                             0                             0                             0                             0
 -0.4612219765891339973152E+00  0.1043862266863211235579E+00  0.4963176271871758693521E+00  0.9247472638411502465772E+00 -0.3761084501259889800728E+00 -0.5818016639828880315344E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           889                             0                             0                             0                             0                             0                             0
 -0.4612219765891339973152E+00  0.1043862266863211235579E+00  0.4382823728128242279922E+00  0.9247472638411502465772E+00 -0.3761084501259889800728E+00  0.5818016639828858804773E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           890                             0                             0                             0                             0                             0                             0
 -0.4539482304976695803411E+00  0.1043862266863211235579E+00  0.3807047437535041600754E+00  0.9101634470731365667007E+00 -0.3761084501259890355840E+00  0.1736229632156190139103E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           891                             0                             0                             0                             0                             0                             0
 -0.4395154496357283613328E+00  0.1043862266863211235579E+00  0.3244927736146899777125E+00  0.8812258090394906595577E+00 -0.3761084501259890355840E+00  0.2863276221857082859401E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           892                             0                             0                             0                             0                             0                             0
 -0.4181512475792286687160E+00  0.1043862266863211235579E+00  0.2705329587448744854683E+00  0.8383907135785103603709E+00 -0.3761084501259890910951E+00  0.3945167235100974778561E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           893                             0                             0                             0                             0                             0                             0
 -0.3901925505569566743347E+00  0.1043862266863211235579E+00  0.2196762776585845511335E+00  0.7823336957340600861244E+00 -0.3761084501259890355840E+00  0.4964840604318667138806E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           894                             0                             0                             0                             0                             0                             0
 -0.3560802839226705485132E+00  0.1043862266863211235579E+00  0.1727247705968610325122E+00  0.7139388081643878170013E+00 -0.3761084501259890355840E+00  0.5906215471354223645051E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           895                             0                             0                             0                             0                             0                             0
 -0.3163524184988725784784E+00  0.1043862266863211235579E+00  0.1304188908735370855396E+00  0.6342846791035910980483E+00 -0.3761084501259890910951E+00  0.6754445792204427645444E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           896                             0                             0                             0                             0                             0                             0
 -0.2716354864555727277597E+00  0.1043862266863211235579E+00  0.9342582748415745319548E-01  0.5446275017500296078410E+00 -0.3761084501259890355840E+00  0.7496154468001229309593E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           897                             0                             0                             0                             0                             0                             0
 -0.2226347005236946619000E+00  0.1043862266863211235579E+00  0.6232898313695778291788E-01  0.4463812233491714076550E+00 -0.3761084501259890355840E+00  0.8119644309852024344210E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           898                             0                             0                             0                             0                             0                             0
 -0.1701228323690336385887E+00  0.1043862266863211235579E+00  0.3761877364364718534517E-01  0.3410952464008777385018E+00 -0.3761084501259890355840E+00  0.8615082510496060441696E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           899                             0                             0                             0                             0                             0                             0
 -0.1149280255214596424551E+00  0.1043862266863211235579E+00  0.1968489376909948740391E-01  0.2304299936564200845801E+00 -0.3761084501259890355840E+00  0.8974655713548730373574E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           900                             0                             0                             0                             0                             0                             0
 -0.5792073505673723393672E-01  0.1043862266863211235579E+00  0.8810171512116438119477E-02  0.1161307222597940252973E+00 -0.3761084501259890355840E+00  0.9192693234799282908654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           901                             0                             0                             0                             0                             0                             0
  0.2745650093261855805827E-16  0.1252491859380355787579E+00  0.1890131146817441987196E-01 -0.4615100205552493258781E-16 -0.6572151062640398944126E+00  0.7537030609585891882674E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           902                             0                             0                             0                             0                             0                             0
  0.5619925755968701447385E-01  0.1252491859380355787579E+00  0.2243706905744424773275E-01 -0.9446404177725391260179E-01 -0.6572151062640400054349E+00  0.7477598872027384491190E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           903                             0                             0                             0                             0                             0                             0
  0.1115122192558485464398E+00  0.1252491859380355787579E+00  0.3298858081591193869286E-01 -0.1874383291855971911399E+00 -0.6572151062640397833903E+00  0.7300240933355955919026E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           904                             0                             0                             0                             0                             0                             0
  0.1650665666401745779179E+00  0.1252491859380355787579E+00  0.5038944309997867021522E-01 -0.2774566021724533260162E+00 -0.6572151062640398944126E+00  0.7007753834212955279526E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           905                             0                             0                             0                             0                             0                             0
  0.2160177156625976424564E+00  0.1252491859380355787579E+00  0.7436523391665345039669E-01 -0.3630992187985094266089E+00 -0.6572151062640398944126E+00  0.6604750270875190398812E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           906                             0                             0                             0                             0                             0                             0
  0.2635621362662931566057E+00  0.1252491859380355787579E+00  0.1045378407223142569471E+00 -0.4430155438391535915876E+00 -0.6572151062640398944126E+00  0.6097585850279155783582E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           907                             0                             0                             0                             0                             0                             0
  0.3069500245366806323588E+00  0.1252491859380355787579E+00  0.1404314234833940466807E+00 -0.5159452491087962444638E+00 -0.6572151062640398944126E+00  0.5494258858302992765132E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           908                             0                             0                             0                             0                             0                             0
  0.3454971275570680178113E+00  0.1252491859380355787579E+00  0.1814799189579637261893E+00 -0.5807381895892409495730E+00 -0.6572151062640398944126E+00  0.4804284122020237579598E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           909                             0                             0                             0                             0                             0                             0
  0.3785955344859005533564E+00  0.1252491859380355787579E+00  0.2270359678512065548794E+00 -0.6363725419036845298848E+00 -0.6572151062640400054349E+00  0.4038542955193000771885E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           910                             0                             0                             0                             0                             0                             0
  0.4057232636738805076071E+00  0.1252491859380355787579E+00  0.2763811240582116912634E+00 -0.6819709190817769828286E+00 -0.6572151062640398944126E+00  0.3209111553453748433284E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           911                             0                             0                             0                             0                             0                             0
  0.4264524946263936189261E+00  0.1252491859380355787579E+00  0.3287371849882270713472E+00 -0.7168142074762695603596E+00 -0.6572151062640397833903E+00  0.2329070545486209842245E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           912                             0                             0                             0                             0                             0                             0
  0.4404563149882765316079E+00  0.1252491859380355787579E+00  0.3832784642843916067534E+00 -0.7403529076148098742038E+00 -0.6572151062640398944126E+00  0.1412298703697049961914E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           913                             0                             0                             0                             0                             0                             0
  0.4475138761469454329323E+00  0.1252491859380355787579E+00  0.4391448133908238404821E+00 -0.7522158001348748790349E+00 -0.6572151062640398944126E+00  0.4732540676842362376009E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           914                             0                             0                             0                             0                             0                             0
  0.4475138761469454329323E+00  0.1252491859380355787579E+00  0.4954551866091761458399E+00 -0.7522158001348748790349E+00 -0.6572151062640398944126E+00 -0.4732540676842362376009E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           915                             0                             0                             0                             0                             0                             0
  0.4404563149882765316079E+00  0.1252491859380355787579E+00  0.5513215357156083795687E+00 -0.7403529076148098742038E+00 -0.6572151062640398944126E+00 -0.1412298703697049961914E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           916                             0                             0                             0                             0                             0                             0
  0.4264524946263936744373E+00  0.1252491859380355787579E+00  0.6058628150117728594637E+00 -0.7168142074762696713819E+00 -0.6572151062640398944126E+00 -0.2329070545486208176911E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           917                             0                             0                             0                             0                             0                             0
  0.4057232636738804520959E+00  0.1252491859380355787579E+00  0.6582188759417884060809E+00 -0.6819709190817768718063E+00 -0.6572151062640398944126E+00 -0.3209111553453749543507E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           918                             0                             0                             0                             0                             0                             0
  0.3785955344859003868230E+00  0.1252491859380355787579E+00  0.7075640321487935979761E+00 -0.6363725419036841968179E+00 -0.6572151062640397833903E+00 -0.4038542955193003547443E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           919                             0                             0                             0                             0                             0                             0
  0.3454971275570679623002E+00  0.1252491859380355787579E+00  0.7531200810420363156439E+00 -0.5807381895892408385507E+00 -0.6572151062640398944126E+00 -0.4804284122020238134709E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           920                             0                             0                             0                             0                             0                             0
  0.3069500245366807433811E+00  0.1252491859380355787579E+00  0.7941685765166057731079E+00 -0.5159452491087963554861E+00 -0.6572151062640398944126E+00 -0.5494258858302990544686E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           921                             0                             0                             0                             0                             0                             0
  0.2635621362662931566057E+00  0.1252491859380355787579E+00  0.8300621592776857848861E+00 -0.4430155438391535915876E+00 -0.6572151062640398944126E+00 -0.6097585850279155783582E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           922                             0                             0                             0                             0                             0                             0
  0.2160177156625975869453E+00  0.1252491859380355787579E+00  0.8602347660833464804142E+00 -0.3630992187985093155866E+00 -0.6572151062640398944126E+00 -0.6604750270875191509035E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           923                             0                             0                             0                             0                             0                             0
  0.1650665666401745779179E+00  0.1252491859380355787579E+00  0.8842105569000213716180E+00 -0.2774566021724533260162E+00 -0.6572151062640398944126E+00 -0.7007753834212955279526E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           924                             0                             0                             0                             0                             0                             0
  0.1115122192558487407288E+00  0.1252491859380355787579E+00  0.9016114191840880476292E+00 -0.1874383291855975242068E+00 -0.6572151062640398944126E+00 -0.7300240933355955919026E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           925                             0                             0                             0                             0                             0                             0
  0.5619925755968711161836E-01  0.1252491859380355787579E+00  0.9121629309425556275670E+00 -0.9446404177725407913524E-01 -0.6572151062640398944126E+00 -0.7477598872027383380967E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           926                             0                             0                             0                             0                             0                             0
  0.2745650093261855805827E-16  0.1252491859380355787579E+00  0.9156986885318255664501E+00 -0.4615100205552493258781E-16 -0.6572151062640398944126E+00 -0.7537030609585891882674E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           927                             0                             0                             0                             0                             0                             0
 -0.5619925755968706304611E-01  0.1252491859380355787579E+00  0.9121629309425556275670E+00  0.9446404177725399586851E-01 -0.6572151062640398944126E+00 -0.7477598872027383380967E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           928                             0                             0                             0                             0                             0                             0
 -0.1115122192558484909286E+00  0.1252491859380355787579E+00  0.9016114191840880476292E+00  0.1874383291855971078732E+00 -0.6572151062640398944126E+00 -0.7300240933355957029249E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           929                             0                             0                             0                             0                             0                             0
 -0.1650665666401745224068E+00  0.1252491859380355787579E+00  0.8842105569000213716180E+00  0.2774566021724532149939E+00 -0.6572151062640398944126E+00 -0.7007753834212955279526E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           930                             0                             0                             0                             0                             0                             0
 -0.2160177156625976979676E+00  0.1252491859380355787579E+00  0.8602347660833464804142E+00  0.3630992187985095376312E+00 -0.6572151062640398944126E+00 -0.6604750270875189288589E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           931                             0                             0                             0                             0                             0                             0
 -0.2635621362662929900722E+00  0.1252491859380355787579E+00  0.8300621592776858959084E+00  0.4430155438391532585207E+00 -0.6572151062640400054349E+00 -0.6097585850279159114251E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           932                             0                             0                             0                             0                             0                             0
 -0.3069500245366805768477E+00  0.1252491859380355787579E+00  0.7941685765166059951525E+00  0.5159452491087960224192E+00 -0.6572151062640398944126E+00 -0.5494258858302993875355E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           933                             0                             0                             0                             0                             0                             0
 -0.3454971275570680733225E+00  0.1252491859380355787579E+00  0.7531200810420362046216E+00  0.5807381895892409495730E+00 -0.6572151062640398944126E+00 -0.4804284122020236469375E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           934                             0                             0                             0                             0                             0                             0
 -0.3785955344859006088676E+00  0.1252491859380355787579E+00  0.7075640321487932649092E+00  0.6363725419036846409071E+00 -0.6572151062640398944126E+00 -0.4038542955192998551439E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           935                             0                             0                             0                             0                             0                             0
 -0.4057232636738806186294E+00  0.1252491859380355787579E+00  0.6582188759417880730140E+00  0.6819709190817770938509E+00 -0.6572151062640398944126E+00 -0.3209111553453744547504E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           936                             0                             0                             0                             0                             0                             0
 -0.4264524946263936189261E+00  0.1252491859380355787579E+00  0.6058628150117729704860E+00  0.7168142074762695603596E+00 -0.6572151062640397833903E+00 -0.2329070545486210674913E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           937                             0                             0                             0                             0                             0                             0
 -0.4404563149882765316079E+00  0.1252491859380355787579E+00  0.5513215357156082685464E+00  0.7403529076148098742038E+00 -0.6572151062640398944126E+00 -0.1412298703697049406802E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           938                             0                             0                             0                             0                             0                             0
 -0.4475138761469454329323E+00  0.1252491859380355787579E+00  0.4954551866091759793065E+00  0.7522158001348748790349E+00 -0.6572151062640398944126E+00 -0.4732540676842338783770E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           939                             0                             0                             0                             0                             0                             0
 -0.4475138761469454329323E+00  0.1252491859380355787579E+00  0.4391448133908241180379E+00  0.7522158001348748790349E+00 -0.6572151062640398944126E+00  0.4732540676842320742645E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           940                             0                             0                             0                             0                             0                             0
 -0.4404563149882765316079E+00  0.1252491859380355787579E+00  0.3832784642843917732868E+00  0.7403529076148098742038E+00 -0.6572151062640398944126E+00  0.1412298703697047463912E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           941                             0                             0                             0                             0                             0                             0
 -0.4264524946263936744373E+00  0.1252491859380355787579E+00  0.3287371849882271268584E+00  0.7168142074762696713819E+00 -0.6572151062640398944126E+00  0.2329070545486209009578E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           942                             0                             0                             0                             0                             0                             0
 -0.4057232636738806741405E+00  0.1252491859380355787579E+00  0.2763811240582119688192E+00  0.6819709190817772048732E+00 -0.6572151062640398944126E+00  0.3209111553453742882169E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           943                             0                             0                             0                             0                             0                             0
 -0.3785955344859004423341E+00  0.1252491859380355787579E+00  0.2270359678512064716127E+00  0.6363725419036843078402E+00 -0.6572151062640398944126E+00  0.4038542955193002992331E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           944                             0                             0                             0                             0                             0                             0
 -0.3454971275570681843448E+00  0.1252491859380355787579E+00  0.1814799189579638927228E+00  0.5807381895892411716176E+00 -0.6572151062640398944126E+00  0.4804284122020234804040E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           945                             0                             0                             0                             0                             0                             0
 -0.3069500245366807988923E+00  0.1252491859380355787579E+00  0.1404314234833941577030E+00  0.5159452491087964665084E+00 -0.6572151062640398944126E+00  0.5494258858302990544686E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           946                             0                             0                             0                             0                             0                             0
 -0.2635621362662932121168E+00  0.1252491859380355787579E+00  0.1045378407223143124583E+00  0.4430155438391537026099E+00 -0.6572151062640398944126E+00  0.6097585850279155783582E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           947                             0                             0                             0                             0                             0                             0
 -0.2160177156625979755233E+00  0.1252491859380355787579E+00  0.7436523391665367244130E-01  0.3630992187985099817205E+00 -0.6572151062640398944126E+00  0.6604750270875187068143E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           948                             0                             0                             0                             0                             0                             0
 -0.1650665666401744668956E+00  0.1252491859380355787579E+00  0.5038944309997861470407E-01  0.2774566021724531039716E+00 -0.6572151062640398944126E+00  0.7007753834212956389749E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           949                             0                             0                             0                             0                             0                             0
 -0.1115122192558487962399E+00  0.1252491859380355787579E+00  0.3298858081591199420401E-01  0.1874383291855976074736E+00 -0.6572151062640398944126E+00  0.7300240933355955919026E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           950                             0                             0                             0                             0                             0                             0
 -0.5619925755968716019062E-01  0.1252491859380355787579E+00  0.2243706905744430324390E-01  0.9446404177725416240197E-01 -0.6572151062640398944126E+00  0.7477598872027383380967E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           951                             0                             0                             0                             0                             0                             0
  0.2618816711648114258985E-16  0.1437667757714512495326E+00  0.3961477459926626698561E-01 -0.2806759479206384675450E-16 -0.8887570259422461482757E+00  0.4583786086176944718495E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           952                             0                             0                             0                             0                             0                             0
  0.5360317224715227535370E-01  0.1437667757714512495326E+00  0.4298720034493591635183E-01 -0.5745007321476230943702E-01 -0.8887570259422462592980E+00  0.4547641563776899098492E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           953                             0                             0                             0                             0                             0                             0
  0.1063609904469839384511E+00  0.1437667757714512495326E+00  0.5305129241334621825743E-01 -0.1139941244559175559381E+00 -0.8887570259422460372534E+00  0.4439778017286700739774E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           954                             0                             0                             0                             0                             0                             0
  0.1574414322904908181133E+00  0.1437667757714512495326E+00  0.6964833406058107412306E-01 -0.1687404202576139045089E+00 -0.8887570259422461482757E+00  0.4261896519269061101021E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           955                             0                             0                             0                             0                             0                             0
  0.2060389286958237420322E+00  0.1437667757714512495326E+00  0.9251658002527152202532E-01 -0.2208255788312065148737E+00 -0.8887570259422461482757E+00  0.4016802367208973656432E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           956                             0                             0                             0                             0                             0                             0
  0.2513870681139335205856E+00  0.1437667757714512495326E+00  0.1212953844077264697887E+00 -0.2694281861118243415198E+00 -0.8887570259422461482757E+00  0.3708360842296575810018E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           957                             0                             0                             0                             0                             0                             0
  0.2927706832965311645189E+00  0.1437667757714512495326E+00  0.1555308882712100881918E+00 -0.3137817499488618211423E+00 -0.8887570259422461482757E+00  0.3341436251633771448155E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           958                             0                             0                             0                             0                             0                             0
  0.3295371299108136864398E+00  0.1437667757714512495326E+00  0.1946831772684967098996E+00 -0.3531867881450740931371E+00 -0.8887570259422461482757E+00  0.2921815215205438853729E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           959                             0                             0                             0                             0                             0                             0
  0.3611065791304632899283E+00  0.1437667757714512495326E+00  0.2381347964136551198511E+00 -0.3870218597086781397998E+00 -0.8887570259422462592980E+00  0.2456115407425510654971E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           960                             0                             0                             0                             0                             0                             0
  0.3869811618826111132563E+00  0.1437667757714512495326E+00  0.2852004877160271845149E+00 -0.4147533653490236837946E+00 -0.8887570259422461482757E+00  0.1951681192458256386413E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           961                             0                             0                             0                             0                             0                             0
  0.4067528205405293029173E+00  0.1437667757714512495326E+00  0.3351379971080933328764E+00 -0.4359439626561641412117E+00 -0.8887570259422460372534E+00  0.1416467799208103173214E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           962                             0                             0                             0                             0                             0                             0
  0.4201097442361662603894E+00  0.1437667757714512495326E+00  0.3871597802355185580225E+00 -0.4502594632519167361373E+00 -0.8887570259422462592980E+00  0.8589158626075896196816E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           963                             0                             0                             0                             0                             0                             0
  0.4268412863038021920481E+00  0.1437667757714512495326E+00  0.4404454225020764113196E+00 -0.4574741031402207447343E+00 -0.8887570259422462592980E+00  0.2878183097622887334777E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           964                             0                             0                             0                             0                             0                             0
  0.4268412863038021920481E+00  0.1437667757714512495326E+00  0.4941545774979235750024E+00 -0.4574741031402207447343E+00 -0.8887570259422462592980E+00 -0.2878183097622887334777E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           965                             0                             0                             0                             0                             0                             0
  0.4201097442361662603894E+00  0.1437667757714512495326E+00  0.5474402197644814282995E+00 -0.4502594632519167361373E+00 -0.8887570259422462592980E+00 -0.8589158626075896196816E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           966                             0                             0                             0                             0                             0                             0
  0.4067528205405293584285E+00  0.1437667757714512495326E+00  0.5994620028919065424233E+00 -0.4359439626561641967228E+00 -0.8887570259422461482757E+00 -0.1416467799208102062991E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           967                             0                             0                             0                             0                             0                             0
  0.3869811618826110577452E+00  0.1437667757714512495326E+00  0.6493995122839728573183E+00 -0.4147533653490236282835E+00 -0.8887570259422462592980E+00 -0.1951681192458257219080E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           968                             0                             0                             0                             0                             0                             0
  0.3611065791304631233949E+00  0.1437667757714512495326E+00  0.6964652035863450052489E+00 -0.3870218597086779732663E+00 -0.8887570259422460372534E+00 -0.2456115407425512320305E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           969                             0                             0                             0                             0                             0                             0
  0.3295371299108136309286E+00  0.1437667757714512495326E+00  0.7399168227315033874447E+00 -0.3531867881450740376259E+00 -0.8887570259422460372534E+00 -0.2921815215205439408841E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           970                             0                             0                             0                             0                             0                             0
  0.2927706832965312200301E+00  0.1437667757714512495326E+00  0.7790691117287897871080E+00 -0.3137817499488618766534E+00 -0.8887570259422461482757E+00 -0.3341436251633770337932E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           971                             0                             0                             0                             0                             0                             0
  0.2513870681139335205856E+00  0.1437667757714512495326E+00  0.8133046155922735165333E+00 -0.2694281861118243415198E+00 -0.8887570259422461482757E+00 -0.3708360842296575810018E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           972                             0                             0                             0                             0                             0                             0
  0.2060389286958236587655E+00  0.1437667757714512495326E+00  0.8420834199747284642967E+00 -0.2208255788312064316070E+00 -0.8887570259422461482757E+00 -0.4016802367208974211543E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           973                             0                             0                             0                             0                             0                             0
  0.1574414322904908181133E+00  0.1437667757714512495326E+00  0.8649516659394189677101E+00 -0.1687404202576139045089E+00 -0.8887570259422461482757E+00 -0.4261896519269061101021E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           974                             0                             0                             0                             0                             0                             0
  0.1063609904469841327401E+00  0.1437667757714512495326E+00  0.8815487075866537125535E+00 -0.1139941244559177502271E+00 -0.8887570259422460372534E+00 -0.4439778017286700184663E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           975                             0                             0                             0                             0                             0                             0
  0.5360317224715236555932E-01  0.1437667757714512495326E+00  0.8916127996550640144591E+00 -0.5745007321476241352043E-01 -0.8887570259422461482757E+00 -0.4547641563776898543381E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           976                             0                             0                             0                             0                             0                             0
  0.2618816711648114258985E-16  0.1437667757714512495326E+00  0.8949852254007337748476E+00 -0.2806759479206384675450E-16 -0.8887570259422461482757E+00 -0.4583786086176944718495E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           977                             0                             0                             0                             0                             0                             0
 -0.5360317224715231698706E-01  0.1437667757714512495326E+00  0.8916127996550640144591E+00  0.5745007321476235800928E-01 -0.8887570259422461482757E+00 -0.4547641563776898543381E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           978                             0                             0                             0                             0                             0                             0
 -0.1063609904469838829399E+00  0.1437667757714512495326E+00  0.8815487075866538235758E+00  0.1139941244559175004269E+00 -0.8887570259422461482757E+00 -0.4439778017286701294886E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           979                             0                             0                             0                             0                             0                             0
 -0.1574414322904907903578E+00  0.1437667757714512495326E+00  0.8649516659394189677101E+00  0.1687404202576138489977E+00 -0.8887570259422460372534E+00 -0.4261896519269061101021E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           980                             0                             0                             0                             0                             0                             0
 -0.2060389286958237697878E+00  0.1437667757714512495326E+00  0.8420834199747284642967E+00  0.2208255788312065426293E+00 -0.8887570259422461482757E+00 -0.4016802367208973101320E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           981                             0                             0                             0                             0                             0                             0
 -0.2513870681139332985410E+00  0.1437667757714512495326E+00  0.8133046155922736275556E+00  0.2694281861118241194752E+00 -0.8887570259422461482757E+00 -0.3708360842296577475352E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           982                             0                             0                             0                             0                             0                             0
 -0.2927706832965310534966E+00  0.1437667757714512495326E+00  0.7790691117287900091526E+00  0.3137817499488617101200E+00 -0.8887570259422461482757E+00 -0.3341436251633772558378E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           983                             0                             0                             0                             0                             0                             0
 -0.3295371299108137419509E+00  0.1437667757714512495326E+00  0.7399168227315032764224E+00  0.3531867881450741486482E+00 -0.8887570259422461482757E+00 -0.2921815215205438298618E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           984                             0                             0                             0                             0                             0                             0
 -0.3611065791304633454395E+00  0.1437667757714512495326E+00  0.6964652035863447832043E+00  0.3870218597086781397998E+00 -0.8887570259422460372534E+00 -0.2456115407425509267192E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           985                             0                             0                             0                             0                             0                             0
 -0.3869811618826112242786E+00  0.1437667757714512495326E+00  0.6493995122839726352737E+00  0.4147533653490237948169E+00 -0.8887570259422461482757E+00 -0.1951681192458254165967E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           986                             0                             0                             0                             0                             0                             0
 -0.4067528205405293029173E+00  0.1437667757714512495326E+00  0.5994620028919066534456E+00  0.4359439626561641412117E+00 -0.8887570259422460372534E+00 -0.1416467799208103450770E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           987                             0                             0                             0                             0                             0                             0
 -0.4201097442361662603894E+00  0.1437667757714512495326E+00  0.5474402197644814282995E+00  0.4502594632519167361373E+00 -0.8887570259422462592980E+00 -0.8589158626075893421259E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           988                             0                             0                             0                             0                             0                             0
 -0.4268412863038021920481E+00  0.1437667757714512495326E+00  0.4941545774979234639801E+00  0.4574741031402207447343E+00 -0.8887570259422461482757E+00 -0.2878183097622872763099E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           989                             0                             0                             0                             0                             0                             0
 -0.4268412863038021920481E+00  0.1437667757714512495326E+00  0.4404454225020766333643E+00  0.4574741031402207447343E+00 -0.8887570259422461482757E+00  0.2878183097622862007814E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           990                             0                             0                             0                             0                             0                             0
 -0.4201097442361662603894E+00  0.1437667757714512495326E+00  0.3871597802355186690448E+00  0.4502594632519167361373E+00 -0.8887570259422461482757E+00  0.8589158626075880931250E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           991                             0                             0                             0                             0                             0                             0
 -0.4067528205405293584285E+00  0.1437667757714512495326E+00  0.3351379971080933883876E+00  0.4359439626561641967228E+00 -0.8887570259422461482757E+00  0.1416467799208102618103E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           992                             0                             0                             0                             0                             0                             0
 -0.3869811618826112242786E+00  0.1437667757714512495326E+00  0.2852004877160274620707E+00  0.4147533653490238503281E+00 -0.8887570259422461482757E+00  0.1951681192458253055744E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           993                             0                             0                             0                             0                             0                             0
 -0.3611065791304631789060E+00  0.1437667757714512495326E+00  0.2381347964136550088288E+00  0.3870218597086780287775E+00 -0.8887570259422461482757E+00  0.2456115407425511765194E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           994                             0                             0                             0                             0                             0                             0
 -0.3295371299108138529732E+00  0.1437667757714512495326E+00  0.1946831772684968209219E+00  0.3531867881450742596705E+00 -0.8887570259422461482757E+00  0.2921815215205437188395E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           995                             0                             0                             0                             0                             0                             0
 -0.2927706832965312755412E+00  0.1437667757714512495326E+00  0.1555308882712101992141E+00  0.3137817499488619321646E+00 -0.8887570259422462592980E+00  0.3341436251633770337932E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           996                             0                             0                             0                             0                             0                             0
 -0.2513870681139335760967E+00  0.1437667757714512495326E+00  0.1212953844077265252999E+00  0.2694281861118243970310E+00 -0.8887570259422461482757E+00  0.3708360842296575254906E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           997                             0                             0                             0                             0                             0                             0
 -0.2060389286958240473435E+00  0.1437667757714512495326E+00  0.9251658002527174406993E-01  0.2208255788312068201851E+00 -0.8887570259422461482757E+00  0.4016802367208971435986E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           998                             0                             0                             0                             0                             0                             0
 -0.1574414322904907070910E+00  0.1437667757714512495326E+00  0.6964833406058107412306E-01  0.1687404202576137657310E+00 -0.8887570259422461482757E+00  0.4261896519269061656132E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           999                             0                             0                             0                             0                             0                             0
 -0.1063609904469841743735E+00  0.1437667757714512495326E+00  0.5305129241334627376858E-01  0.1139941244559178057383E+00 -0.8887570259422461482757E+00  0.4439778017286700184663E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
