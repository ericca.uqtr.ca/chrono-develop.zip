  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           303                             0                             0                             0                             0                             0                             0
  0.1115122192558482827618E+00 -0.1252491859380352179354E+00  0.3298858081591293789359E-01 -0.1874383291855762634359E+00  0.6572151062641361507488E+00  0.7300240933355141015326E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           304                             0                             0                             0                             0                             0                             0
  0.1650665666401741893399E+00 -0.1252491859380352179354E+00  0.5038944309997966941594E-01 -0.2774566021724223507938E+00  0.6572151062641363727934E+00  0.7007753834212172572293E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           305                             0                             0                             0                             0                             0                             0
  0.2160177156625971428561E+00 -0.1252491859380352179354E+00  0.7436523391665439408627E-01 -0.3630992187984689034685E+00  0.6572151062641363727934E+00  0.6604750270874453210723E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           306                             0                             0                             0                             0                             0                             0
  0.2635621362662925459830E+00 -0.1252491859380352179354E+00  0.1045378407223150896144E+00 -0.4430155438391041311519E+00  0.6572151062641362617711E+00  0.6097585850278475216868E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           307                             0                             0                             0                             0                             0                             0
  0.3069500245366799107138E+00 -0.1252491859380352179354E+00  0.1404314234833948238368E+00 -0.5159452491087386238888E+00  0.6572151062641362617711E+00  0.5494258858302378811800E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           308                             0                             0                             0                             0                             0                             0
  0.3454971275570672406552E+00 -0.1252491859380352179354E+00  0.1814799189579643923231E+00 -0.5807381895891761125483E+00  0.6572151062641361507488E+00  0.4804284122019701341877E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           309                             0                             0                             0                             0                             0                             0
  0.3785955344858996651780E+00 -0.1252491859380352179354E+00  0.2270359678512071377465E+00 -0.6363725419036134756112E+00  0.6572151062641363727934E+00  0.4038542955192550021337E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           310                             0                             0                             0                             0                             0                             0
  0.4057232636738795639175E+00 -0.1252491859380352179354E+00  0.2763811240582121353526E+00 -0.6819709190817008215291E+00  0.6572151062641362617711E+00  0.3209111553453389831247E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           311                             0                             0                             0                             0                             0                             0
  0.4264524946263926197254E+00 -0.1252491859380352179354E+00  0.3287371849882273489030E+00 -0.7168142074761895132795E+00  0.6572151062641362617711E+00  0.2329070545485949772502E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           312                             0                             0                             0                             0                             0                             0
  0.4404563149882755324072E+00 -0.1252491859380352179354E+00  0.3832784642843918287980E+00 -0.7403529076147271625885E+00  0.6572151062641363727934E+00  0.1412298703696892310244E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           313                             0                             0                             0                             0                             0                             0
  0.4475138761469443782204E+00 -0.1252491859380352179354E+00  0.4391448133908238959933E+00 -0.7522158001347909461742E+00  0.6572151062641363727934E+00  0.4732540676841834326183E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           314                             0                             0                             0                             0                             0                             0
  0.4475138761469443782204E+00 -0.1252491859380352179354E+00  0.4954551866091760903288E+00 -0.7522158001347909461742E+00  0.6572151062641363727934E+00 -0.4732540676841834326183E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           315                             0                             0                             0                             0                             0                             0
  0.4404563149882755324072E+00 -0.1252491859380352179354E+00  0.5513215357156081575241E+00 -0.7403529076147271625885E+00  0.6572151062641363727934E+00 -0.1412298703696892310244E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           316                             0                             0                             0                             0                             0                             0
  0.4264524946263926752366E+00 -0.1252491859380352179354E+00  0.6058628150117725263968E+00 -0.7168142074761896243018E+00  0.6572151062641361507488E+00 -0.2329070545485948107167E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           317                             0                             0                             0                             0                             0                             0
  0.4057232636738795084064E+00 -0.1252491859380352179354E+00  0.6582188759417879619917E+00 -0.6819709190817007105068E+00  0.6572151062641362617711E+00 -0.3209111553453391496582E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           318                             0                             0                             0                             0                             0                             0
  0.3785955344858994986446E+00 -0.1252491859380352179354E+00  0.7075640321487930428646E+00 -0.6363725419036131425443E+00  0.6572151062641362617711E+00 -0.4038542955192552796895E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           319                             0                             0                             0                             0                             0                             0
  0.3454971275570671851440E+00 -0.1252491859380352179354E+00  0.7531200810420356495101E+00 -0.5807381895891760015260E+00  0.6572151062641362617711E+00 -0.4804284122019701896988E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           320                             0                             0                             0                             0                             0                             0
  0.3069500245366800217361E+00 -0.1252491859380352179354E+00  0.7941685765166051069741E+00 -0.5159452491087387349111E+00  0.6572151062641362617711E+00 -0.5494258858302377701577E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           321                             0                             0                             0                             0                             0                             0
  0.2635621362662925459830E+00 -0.1252491859380352179354E+00  0.8300621592776848967077E+00 -0.4430155438391041311519E+00  0.6572151062641362617711E+00 -0.6097585850278475216868E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           322                             0                             0                             0                             0                             0                             0
  0.2160177156625970595893E+00 -0.1252491859380352179354E+00  0.8602347660833455922358E+00 -0.3630992187984687924462E+00  0.6572151062641363727934E+00 -0.6604750270874453210723E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           323                             0                             0                             0                             0                             0                             0
  0.1650665666401741893399E+00 -0.1252491859380352179354E+00  0.8842105569000202613950E+00 -0.2774566021724223507938E+00  0.6572151062641363727934E+00 -0.7007753834212172572293E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           324                             0                             0                             0                             0                             0                             0
  0.1115122192558484770508E+00 -0.1252491859380352179354E+00  0.9016114191840869374062E+00 -0.1874383291855765965028E+00  0.6572151062641361507488E+00 -0.7300240933355141015326E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           325                             0                             0                             0                             0                             0                             0
  0.5619925755968697977938E-01 -0.1252491859380352179354E+00  0.9121629309425546283663E+00 -0.9446404177724353201651E-01  0.6572151062641362617711E+00 -0.7477598872026548493253E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           326                             0                             0                             0                             0                             0                             0
  0.2745650093261849334703E-16 -0.1252491859380352179354E+00  0.9156986885318245672494E+00 -0.4615100205551978034002E-16  0.6572151062641362617711E+00 -0.7537030609585050333621E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           327                             0                             0                             0                             0                             0                             0
 -0.5619925755968693120712E-01 -0.1252491859380352179354E+00  0.9121629309425546283663E+00  0.9446404177724344874978E-01  0.6572151062641362617711E+00 -0.7477598872026548493253E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           328                             0                             0                             0                             0                             0                             0
 -0.1115122192558482411284E+00 -0.1252491859380352179354E+00  0.9016114191840871594508E+00  0.1874383291855761801692E+00  0.6572151062641363727934E+00 -0.7300240933355142125549E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           329                             0                             0                             0                             0                             0                             0
 -0.1650665666401741338287E+00 -0.1252491859380352179354E+00  0.8842105569000202613950E+00  0.2774566021724222397715E+00  0.6572151062641362617711E+00 -0.7007753834212172572293E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           330                             0                             0                             0                             0                             0                             0
 -0.2160177156625971983672E+00 -0.1252491859380352179354E+00  0.8602347660833455922358E+00  0.3630992187984690144908E+00  0.6572151062641361507488E+00 -0.6604750270874452100500E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           331                             0                             0                             0                             0                             0                             0
 -0.2635621362662923794495E+00 -0.1252491859380352179354E+00  0.8300621592776850077300E+00  0.4430155438391037980850E+00  0.6572151062641362617711E+00 -0.6097585850278477437314E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           332                             0                             0                             0                             0                             0                             0
 -0.3069500245366798552027E+00 -0.1252491859380352179354E+00  0.7941685765166052179964E+00  0.5159452491087384018442E+00  0.6572151062641362617711E+00 -0.5494258858302381032246E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           333                             0                             0                             0                             0                             0                             0
 -0.3454971275570672406552E+00 -0.1252491859380352179354E+00  0.7531200810420355384878E+00  0.5807381895891761125483E+00  0.6572151062641362617711E+00 -0.4804284122019700231654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           334                             0                             0                             0                             0                             0                             0
 -0.3785955344858997206892E+00 -0.1252491859380352179354E+00  0.7075640321487927097976E+00  0.6363725419036135866335E+00  0.6572151062641362617711E+00 -0.4038542955192547800891E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           335                             0                             0                             0                             0                             0                             0
 -0.4057232636738796749398E+00 -0.1252491859380352179354E+00  0.6582188759417876289248E+00  0.6819709190817009325514E+00  0.6572151062641362617711E+00 -0.3209111553453386500578E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           336                             0                             0                             0                             0                             0                             0
 -0.4264524946263926197254E+00 -0.1252491859380352179354E+00  0.6058628150117726374191E+00  0.7168142074761895132795E+00  0.6572151062641362617711E+00 -0.2329070545485950605169E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           337                             0                             0                             0                             0                             0                             0
 -0.4404563149882755324072E+00 -0.1252491859380352179354E+00  0.5513215357156081575241E+00  0.7403529076147271625885E+00  0.6572151062641363727934E+00 -0.1412298703696891755133E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           338                             0                             0                             0                             0                             0                             0
 -0.4475138761469443782204E+00 -0.1252491859380352179354E+00  0.4954551866091759237953E+00  0.7522158001347909461742E+00  0.6572151062641362617711E+00 -0.4732540676841810040054E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           339                             0                             0                             0                             0                             0                             0
 -0.4475138761469443782204E+00 -0.1252491859380352179354E+00  0.4391448133908241735490E+00  0.7522158001347909461742E+00  0.6572151062641362617711E+00  0.4732540676841791998930E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           340                             0                             0                             0                             0                             0                             0
 -0.4404563149882755324072E+00 -0.1252491859380352179354E+00  0.3832784642843919398203E+00  0.7403529076147271625885E+00  0.6572151062641362617711E+00  0.1412298703696889812242E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           341                             0                             0                             0                             0                             0                             0
 -0.4264524946263926752366E+00 -0.1252491859380352179354E+00  0.3287371849882274599253E+00  0.7168142074761896243018E+00  0.6572151062641361507488E+00  0.2329070545485948939834E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           342                             0                             0                             0                             0                             0                             0
 -0.4057232636738797304510E+00 -0.1252491859380352179354E+00  0.2763811240582124684195E+00  0.6819709190817010435737E+00  0.6572151062641363727934E+00  0.3209111553453384835244E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           343                             0                             0                             0                             0                             0                             0
 -0.3785955344858995541557E+00 -0.1252491859380352179354E+00  0.2270359678512070267242E+00  0.6363725419036132535666E+00  0.6572151062641362617711E+00  0.4038542955192551686672E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           344                             0                             0                             0                             0                             0                             0
 -0.3454971275570673516775E+00 -0.1252491859380352179354E+00  0.1814799189579645588566E+00  0.5807381895891763345929E+00  0.6572151062641362617711E+00  0.4804284122019698566319E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           345                             0                             0                             0                             0                             0                             0
 -0.3069500245366800772473E+00 -0.1252491859380352179354E+00  0.1404314234833949348591E+00  0.5159452491087388459334E+00  0.6572151062641362617711E+00  0.5494258858302377701577E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           346                             0                             0                             0                             0                             0                             0
 -0.2635621362662926014941E+00 -0.1252491859380352179354E+00  0.1045378407223151451255E+00  0.4430155438391042421742E+00  0.6572151062641362617711E+00  0.6097585850278474106645E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           347                             0                             0                             0                             0                             0                             0
 -0.2160177156625974759230E+00 -0.1252491859380352179354E+00  0.7436523391665461613087E-01  0.3630992187984694585801E+00  0.6572151062641362617711E+00  0.6604750270874449880054E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           348                             0                             0                             0                             0                             0                             0
 -0.1650665666401740783176E+00 -0.1252491859380352179354E+00  0.5038944309997961390479E-01  0.2774566021724221287492E+00  0.6572151062641361507488E+00  0.7007753834212173682516E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           349                             0                             0                             0                             0                             0                             0
 -0.1115122192558485325620E+00 -0.1252491859380352179354E+00  0.3298858081591299340474E-01  0.1874383291855766797696E+00  0.6572151062641361507488E+00  0.7300240933355141015326E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           350                             0                             0                             0                             0                             0                             0
 -0.5619925755968702835164E-01 -0.1252491859380352179354E+00  0.2243706905744535795577E-01  0.9446404177724361528323E-01  0.6572151062641362617711E+00  0.7477598872026548493253E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           351                             0                             0                             0                             0                             0                             0
  0.2829753959675105425265E-16 -0.1043862266863211651913E+00  0.5166107738934999638047E-02 -0.5673639514979832001175E-16  0.3761084501259887025171E+00  0.9265756492288292900383E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           352                             0                             0                             0                             0                             0                             0
  0.5792073505673708128105E-01 -0.1043862266863211651913E+00  0.8810171512116382608326E-02 -0.1161307222597937199859E+00  0.3761084501259887580282E+00  0.9192693234799284018877E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           353                             0                             0                             0                             0                             0                             0
  0.1149280255214593926549E+00 -0.1043862266863211651913E+00  0.1968489376909943189276E-01 -0.2304299936564195849797E+00  0.3761084501259887025171E+00  0.8974655713548731483797E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           354                             0                             0                             0                             0                             0                             0
  0.1701228323690337773666E+00 -0.1043862266863211651913E+00  0.3761877364364724085632E-01 -0.3410952464008779605464E+00  0.3761084501259887025171E+00  0.8615082510496059331473E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           355                             0                             0                             0                             0                             0                             0
  0.2226347005236943288331E+00 -0.1043862266863211651913E+00  0.6232898313695756087327E-01 -0.4463812233491707415212E+00  0.3761084501259887025171E+00  0.8119644309852028785102E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           356                             0                             0                             0                             0                             0                             0
  0.2716354864555726722486E+00 -0.1043862266863211651913E+00  0.9342582748415739768433E-01 -0.5446275017500294968187E+00  0.3761084501259887025171E+00  0.7496154468001230419816E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           357                             0                             0                             0                             0                             0                             0
  0.3163524184988724119449E+00 -0.1043862266863211651913E+00  0.1304188908735369745173E+00 -0.6342846791035908760037E+00  0.3761084501259887025171E+00  0.6754445792204429865890E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           358                             0                             0                             0                             0                             0                             0
  0.3560802839226703819797E+00 -0.1043862266863211651913E+00  0.1727247705968608659788E+00 -0.7139388081643874839344E+00  0.3761084501259887025171E+00  0.5906215471354226975720E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           359                             0                             0                             0                             0                             0                             0
  0.3901925505569567853570E+00 -0.1043862266863211651913E+00  0.2196762776585846344002E+00 -0.7823336957340603081690E+00  0.3761084501259887025171E+00  0.4964840604318665473471E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           360                             0                             0                             0                             0                             0                             0
  0.4181512475792285021825E+00 -0.1043862266863211651913E+00  0.2705329587448741524014E+00 -0.8383907135785100273040E+00  0.3761084501259887025171E+00  0.3945167235100981439899E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           361                             0                             0                             0                             0                             0                             0
  0.4395154496357283058217E+00 -0.1043862266863211651913E+00  0.3244927736146899222014E+00 -0.8812258090394905485354E+00  0.3761084501259886470059E+00  0.2863276221857083969624E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           362                             0                             0                             0                             0                             0                             0
  0.4539482304976695803411E+00 -0.1043862266863211651913E+00  0.3807047437535039935419E+00 -0.9101634470731365667007E+00  0.3761084501259887580282E+00  0.1736229632156193192216E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           363                             0                             0                             0                             0                             0                             0
  0.4612219765891339973152E+00 -0.1043862266863211651913E+00  0.4382823728128239504365E+00 -0.9247472638411502465772E+00  0.3761084501259886470059E+00  0.5818016639828910152588E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           364                             0                             0                             0                             0                             0                             0
  0.4612219765891339973152E+00 -0.1043862266863211651913E+00  0.4963176271871760358856E+00 -0.9247472638411502465772E+00  0.3761084501259886470059E+00 -0.5818016639828910152588E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           365                             0                             0                             0                             0                             0                             0
  0.4539482304976695803411E+00 -0.1043862266863211651913E+00  0.5538952562464960482913E+00 -0.9101634470731365667007E+00  0.3761084501259887580282E+00 -0.1736229632156193192216E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           366                             0                             0                             0                             0                             0                             0
  0.4395154496357283613328E+00 -0.1043862266863211651913E+00  0.6101072263853100086095E+00 -0.8812258090394906595577E+00  0.3761084501259887025171E+00 -0.2863276221857081749178E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           367                             0                             0                             0                             0                             0                             0
  0.4181512475792284466714E+00 -0.1043862266863211651913E+00  0.6640670412551259449430E+00 -0.8383907135785099162817E+00  0.3761084501259887025171E+00 -0.3945167235100983105234E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           368                             0                             0                             0                             0                             0                             0
  0.3901925505569566188235E+00 -0.1043862266863211651913E+00  0.7149237223414155462109E+00 -0.7823336957340599751021E+00  0.3761084501259887025171E+00 -0.4964840604318668249029E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           369                             0                             0                             0                             0                             0                             0
  0.3560802839226703819797E+00 -0.1043862266863211651913E+00  0.7618752294031392313656E+00 -0.7139388081643873729121E+00  0.3761084501259887025171E+00 -0.5906215471354228085943E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           370                             0                             0                             0                             0                             0                             0
  0.3163524184988725229672E+00 -0.1043862266863211651913E+00  0.8041811091264629007824E+00 -0.6342846791035909870260E+00  0.3761084501259886470059E+00 -0.6754445792204427645444E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           371                             0                             0                             0                             0                             0                             0
  0.2716354864555726722486E+00 -0.1043862266863211651913E+00  0.8411741725158425886377E+00 -0.5446275017500294968187E+00  0.3761084501259887025171E+00 -0.7496154468001230419816E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           372                             0                             0                             0                             0                             0                             0
  0.2226347005236942455664E+00 -0.1043862266863211651913E+00  0.8722710168630424254488E+00 -0.4463812233491705749877E+00  0.3761084501259887025171E+00 -0.8119644309852029895325E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           373                             0                             0                             0                             0                             0                             0
  0.1701228323690337773666E+00 -0.1043862266863211651913E+00  0.8969812263563528009769E+00 -0.3410952464008779605464E+00  0.3761084501259887025171E+00 -0.8615082510496059331473E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           374                             0                             0                             0                             0                             0                             0
  0.1149280255214596008217E+00 -0.1043862266863211651913E+00  0.9149151062309004434070E+00 -0.2304299936564200013134E+00  0.3761084501259886470059E+00 -0.8974655713548730373574E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           375                             0                             0                             0                             0                             0                             0
  0.5792073505673717842557E-01 -0.1043862266863211651913E+00  0.9257898284878836037137E+00 -0.1161307222597939281528E+00  0.3761084501259886470059E+00 -0.9192693234799282908654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           376                             0                             0                             0                             0                             0                             0
  0.2829753959675105425265E-16 -0.1043862266863211651913E+00  0.9294338922610649866840E+00 -0.5673639514979832001175E-16  0.3761084501259887025171E+00 -0.9265756492288292900383E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           377                             0                             0                             0                             0                             0                             0
 -0.5792073505673712985331E-01 -0.1043862266863211651913E+00  0.9257898284878836037137E+00  0.1161307222597938171305E+00  0.3761084501259886470059E+00 -0.9192693234799282908654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           378                             0                             0                             0                             0                             0                             0
 -0.1149280255214593371438E+00 -0.1043862266863211651913E+00  0.9149151062309006654516E+00  0.2304299936564194739574E+00  0.3761084501259887025171E+00 -0.8974655713548732594020E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           379                             0                             0                             0                             0                             0                             0
 -0.1701228323690337218554E+00 -0.1043862266863211651913E+00  0.8969812263563528009769E+00  0.3410952464008778495241E+00  0.3761084501259887025171E+00 -0.8615082510496059331473E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           380                             0                             0                             0                             0                             0                             0
 -0.2226347005236943843443E+00 -0.1043862266863211651913E+00  0.8722710168630423144265E+00  0.4463812233491707970323E+00  0.3761084501259887025171E+00 -0.8119644309852027674879E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           381                             0                             0                             0                             0                             0                             0
 -0.2716354864555725057151E+00 -0.1043862266863211651913E+00  0.8411741725158428106823E+00  0.5446275017500290527295E+00  0.3761084501259887580282E+00 -0.7496154468001233750485E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           382                             0                             0                             0                             0                             0                             0
 -0.3163524184988723009226E+00 -0.1043862266863211651913E+00  0.8041811091264631228270E+00  0.6342846791035906539591E+00  0.3761084501259887025171E+00 -0.6754445792204432086336E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           383                             0                             0                             0                             0                             0                             0
 -0.3560802839226704374909E+00 -0.1043862266863211651913E+00  0.7618752294031390093210E+00  0.7139388081643875949567E+00  0.3761084501259887025171E+00 -0.5906215471354225865497E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           384                             0                             0                             0                             0                             0                             0
 -0.3901925505569568408681E+00 -0.1043862266863211651913E+00  0.7149237223414152131440E+00  0.7823336957340604191913E+00  0.3761084501259887025171E+00 -0.4964840604318662142802E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           385                             0                             0                             0                             0                             0                             0
 -0.4181512475792286132048E+00 -0.1043862266863211651913E+00  0.6640670412551256118761E+00  0.8383907135785102493486E+00  0.3761084501259887025171E+00 -0.3945167235100976999007E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           386                             0                             0                             0                             0                             0                             0
 -0.4395154496357283058217E+00 -0.1043862266863211651913E+00  0.6101072263853101196318E+00  0.8812258090394905485354E+00  0.3761084501259887025171E+00 -0.2863276221857084524736E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           387                             0                             0                             0                             0                             0                             0
 -0.4539482304976695803411E+00 -0.1043862266863211651913E+00  0.5538952562464959372690E+00  0.9101634470731365667007E+00  0.3761084501259887580282E+00 -0.1736229632156192359549E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           388                             0                             0                             0                             0                             0                             0
 -0.4612219765891339973152E+00 -0.1043862266863211651913E+00  0.4963176271871758693521E+00  0.9247472638411502465772E+00  0.3761084501259886470059E+00 -0.5818016639828880315344E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           389                             0                             0                             0                             0                             0                             0
 -0.4612219765891339973152E+00 -0.1043862266863211651913E+00  0.4382823728128242279922E+00  0.9247472638411502465772E+00  0.3761084501259886470059E+00  0.5818016639828858804773E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           390                             0                             0                             0                             0                             0                             0
 -0.4539482304976695803411E+00 -0.1043862266863211651913E+00  0.3807047437535041600754E+00  0.9101634470731365667007E+00  0.3761084501259887025171E+00  0.1736229632156190139103E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           391                             0                             0                             0                             0                             0                             0
 -0.4395154496357283613328E+00 -0.1043862266863211651913E+00  0.3244927736146899777125E+00  0.8812258090394906595577E+00  0.3761084501259887580282E+00  0.2863276221857082859401E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           392                             0                             0                             0                             0                             0                             0
 -0.4181512475792286687160E+00 -0.1043862266863211651913E+00  0.2705329587448744854683E+00  0.8383907135785103603709E+00  0.3761084501259887025171E+00  0.3945167235100974778561E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           393                             0                             0                             0                             0                             0                             0
 -0.3901925505569566743347E+00 -0.1043862266863211651913E+00  0.2196762776585845511335E+00  0.7823336957340600861244E+00  0.3761084501259887025171E+00  0.4964840604318667138806E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           394                             0                             0                             0                             0                             0                             0
 -0.3560802839226705485132E+00 -0.1043862266863211651913E+00  0.1727247705968610325122E+00  0.7139388081643878170013E+00  0.3761084501259887025171E+00  0.5906215471354223645051E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           395                             0                             0                             0                             0                             0                             0
 -0.3163524184988725784784E+00 -0.1043862266863211651913E+00  0.1304188908735370855396E+00  0.6342846791035910980483E+00  0.3761084501259887025171E+00  0.6754445792204427645444E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           396                             0                             0                             0                             0                             0                             0
 -0.2716354864555727277597E+00 -0.1043862266863211651913E+00  0.9342582748415745319548E-01  0.5446275017500296078410E+00  0.3761084501259887025171E+00  0.7496154468001229309593E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           397                             0                             0                             0                             0                             0                             0
 -0.2226347005236946619000E+00 -0.1043862266863211651913E+00  0.6232898313695778291788E-01  0.4463812233491714076550E+00  0.3761084501259887025171E+00  0.8119644309852024344210E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           398                             0                             0                             0                             0                             0                             0
 -0.1701228323690336385887E+00 -0.1043862266863211651913E+00  0.3761877364364718534517E-01  0.3410952464008777385018E+00  0.3761084501259887025171E+00  0.8615082510496060441696E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           399                             0                             0                             0                             0                             0                             0
 -0.1149280255214596424551E+00 -0.1043862266863211651913E+00  0.1968489376909948740391E-01  0.2304299936564200845801E+00  0.3761084501259886470059E+00  0.8974655713548730373574E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           400                             0                             0                             0                             0                             0                             0
 -0.5792073505673723393672E-01 -0.1043862266863211651913E+00  0.8810171512116438119477E-02  0.1161307222597940252973E+00  0.3761084501259887025171E+00  0.9192693234799282908654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           401                             0                             0                             0                             0                             0                             0
  0.2855786811015745030862E-16 -0.8350873084007630342551E-01  0.9146204760335785444170E-03 -0.6113906976003832489457E-16  0.5517350488583738776782E-01  0.9984767820828949203005E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           402                             0                             0                             0                             0                             0                             0
  0.5845358770285397076449E-01 -0.8350873084007630342551E-01  0.4592208496140670614949E-02 -0.1251423237373303909425E+00  0.5517350488583739470672E-01  0.9906034944256123520034E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           403                             0                             0                             0                             0                             0                             0
  0.1159853274091531549761E+00 -0.8350873084007630342551E-01  0.1556697479650026583187E-01 -0.2483110782729223975362E+00  0.5517350488583738082893E-01  0.9671077979033936289355E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           404                             0                             0                             0                             0                             0                             0
  0.1716879092159339648127E+00 -0.8350873084007630342551E-01  0.3366584075654810437328E-01 -0.3675638187703024750697E+00  0.5517350488583738776782E-01  0.9283602336860433679178E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           405                             0                             0                             0                             0                             0                             0
  0.2246828701329937338915E+00 -0.8350873084007630342551E-01  0.5860337644835567072477E-01 -0.4810198582736923689218E+00  0.5517350488583738776782E-01  0.8749718740079418521915E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           406                             0                             0                             0                             0                             0                             0
  0.2741344479690154267715E+00 -0.8350873084007630342551E-01  0.8998630203710150654572E-01 -0.5868899272647710718687E+00  0.5517350488583739470672E-01  0.8077846851938730310394E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           407                             0                             0                             0                             0                             0                             0
  0.3192627618005842715654E+00 -0.8350873084007630342551E-01  0.1273196900390001218284E+00 -0.6835043915118356183669E+00  0.5517350488583738776782E-01  0.7278582493471157377485E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           408                             0                             0                             0                             0                             0                             0
  0.3593561111602285307320E+00 -0.8350873084007630342551E-01  0.1700147706233764988148E+00 -0.7693395831990263999955E+00  0.5517350488583738776782E-01  0.6364530541067118241116E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           409                             0                             0                             0                             0                             0                             0
  0.3937821999779406167974E+00 -0.8350873084007630342551E-01  0.2173982168646101387210E+00 -0.8430418300779783935539E+00  0.5517350488583739470672E-01  0.5350106140044195157657E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           410                             0                             0                             0                             0                             0                             0
  0.4219981082679163941762E+00 -0.8350873084007630342551E-01  0.2687227635099780354011E+00 -0.9034488036878219885395E+00  0.5517350488583738776782E-01  0.4251307369194283758418E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           411                             0                             0                             0                             0                             0                             0
  0.4435588543010565154567E+00 -0.8350873084007630342551E-01  0.3231789917990847693652E+00 -0.9496078499693532126713E+00  0.5517350488583738082893E-01  0.3085462941524255153780E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           412                             0                             0                             0                             0                             0                             0
  0.4581244122326530443523E+00 -0.8350873084007630342551E-01  0.3799080944812370796981E+00 -0.9807910131886349303088E+00  0.5517350488583739470672E-01  0.1870958920100169731171E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           413                             0                             0                             0                             0                             0                             0
  0.4654650745130819999851E+00 -0.8350873084007630342551E-01  0.4380154197188141362851E+00 -0.9965065162337798376768E+00  0.5517350488583738776782E-01  0.6269487588494207508383E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           414                             0                             0                             0                             0                             0                             0
  0.4654650745130819999851E+00 -0.8350873084007630342551E-01  0.4965845802811858500370E+00 -0.9965065162337798376768E+00  0.5517350488583738776782E-01 -0.6269487588494207508383E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           415                             0                             0                             0                             0                             0                             0
  0.4581244122326530443523E+00 -0.8350873084007630342551E-01  0.5546919055187629066239E+00 -0.9807910131886349303088E+00  0.5517350488583739470672E-01 -0.1870958920100169731171E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           416                             0                             0                             0                             0                             0                             0
  0.4435588543010565709679E+00 -0.8350873084007630342551E-01  0.6114210082009151614457E+00 -0.9496078499693533236936E+00  0.5517350488583738776782E-01 -0.3085462941524252933334E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           417                             0                             0                             0                             0                             0                             0
  0.4219981082679163386651E+00 -0.8350873084007630342551E-01  0.6658772364900220619433E+00 -0.9034488036878218775172E+00  0.5517350488583738776782E-01 -0.4251307369194285423752E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           418                             0                             0                             0                             0                             0                             0
  0.3937821999779404502640E+00 -0.8350873084007630342551E-01  0.7172017831353899586233E+00 -0.8430418300779780604870E+00  0.5517350488583738082893E-01 -0.5350106140044198488326E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           419                             0                             0                             0                             0                             0                             0
  0.3593561111602284752209E+00 -0.8350873084007630342551E-01  0.7645852293766235430184E+00 -0.7693395831990262889732E+00  0.5517350488583738082893E-01 -0.6364530541067119351339E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           420                             0                             0                             0                             0                             0                             0
  0.3192627618005843825877E+00 -0.8350873084007630342551E-01  0.8072803099609997534714E+00 -0.6835043915118358404115E+00  0.5517350488583738082893E-01 -0.7278582493471155157039E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           421                             0                             0                             0                             0                             0                             0
  0.2741344479690154267715E+00 -0.8350873084007630342551E-01  0.8446136979628984242652E+00 -0.5868899272647710718687E+00  0.5517350488583739470672E-01 -0.8077846851938730310394E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           422                             0                             0                             0                             0                             0                             0
  0.2246828701329936506248E+00 -0.8350873084007630342551E-01  0.8759966235516443155973E+00 -0.4810198582736922023884E+00  0.5517350488583738776782E-01 -0.8749718740079419632139E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           423                             0                             0                             0                             0                             0                             0
  0.1716879092159339648127E+00 -0.8350873084007630342551E-01  0.9009341592434518819488E+00 -0.3675638187703024750697E+00  0.5517350488583738776782E-01 -0.9283602336860433679178E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           424                             0                             0                             0                             0                             0                             0
  0.1159853274091533631429E+00 -0.8350873084007630342551E-01  0.9190330252034997204902E+00 -0.2483110782729228416255E+00  0.5517350488583738776782E-01 -0.9671077979033935179132E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           425                             0                             0                             0                             0                             0                             0
  0.5845358770285406790901E-01 -0.8350873084007630342551E-01  0.9300077915038592601960E+00 -0.1251423237373306129872E+00  0.5517350488583738776782E-01 -0.9906034944256122409811E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           426                             0                             0                             0                             0                             0                             0
  0.2855786811015745030862E-16 -0.8350873084007630342551E-01  0.9336853795239663522665E+00 -0.6113906976003832489457E-16  0.5517350488583738776782E-01 -0.9984767820828949203005E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           427                             0                             0                             0                             0                             0                             0
 -0.5845358770285401933675E-01 -0.8350873084007630342551E-01  0.9300077915038592601960E+00  0.1251423237373305019648E+00  0.5517350488583738776782E-01 -0.9906034944256122409811E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           428                             0                             0                             0                             0                             0                             0
 -0.1159853274091531133427E+00 -0.8350873084007630342551E-01  0.9190330252034997204902E+00  0.2483110782729222865139E+00  0.5517350488583738776782E-01 -0.9671077979033937399578E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           429                             0                             0                             0                             0                             0                             0
 -0.1716879092159339093016E+00 -0.8350873084007630342551E-01  0.9009341592434518819488E+00  0.3675638187703023640474E+00  0.5517350488583738776782E-01 -0.9283602336860433679178E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           430                             0                             0                             0                             0                             0                             0
 -0.2246828701329937894027E+00 -0.8350873084007630342551E-01  0.8759966235516443155973E+00  0.4810198582736924799441E+00  0.5517350488583738776782E-01 -0.8749718740079417411692E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           431                             0                             0                             0                             0                             0                             0
 -0.2741344479690152047269E+00 -0.8350873084007630342551E-01  0.8446136979628986463098E+00  0.5868899272647706277795E+00  0.5517350488583738776782E-01 -0.8077846851938733641063E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           432                             0                             0                             0                             0                             0                             0
 -0.3192627618005841605431E+00 -0.8350873084007630342551E-01  0.8072803099609999755160E+00  0.6835043915118353963223E+00  0.5517350488583738776782E-01 -0.7278582493471159597931E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           433                             0                             0                             0                             0                             0                             0
 -0.3593561111602285862432E+00 -0.8350873084007630342551E-01  0.7645852293766234319961E+00  0.7693395831990265110178E+00  0.5517350488583738776782E-01 -0.6364530541067117130893E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           434                             0                             0                             0                             0                             0                             0
 -0.3937821999779406723086E+00 -0.8350873084007630342551E-01  0.7172017831353896255564E+00  0.8430418300779785045762E+00  0.5517350488583738776782E-01 -0.5350106140044191826988E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           435                             0                             0                             0                             0                             0                             0
 -0.4219981082679165051985E+00 -0.8350873084007630342551E-01  0.6658772364900217288763E+00  0.9034488036878222105841E+00  0.5517350488583738776782E-01 -0.4251307369194278762414E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           436                             0                             0                             0                             0                             0                             0
 -0.4435588543010565154567E+00 -0.8350873084007630342551E-01  0.6114210082009152724680E+00  0.9496078499693532126713E+00  0.5517350488583738082893E-01 -0.3085462941524256264003E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           437                             0                             0                             0                             0                             0                             0
 -0.4581244122326530443523E+00 -0.8350873084007630342551E-01  0.5546919055187629066239E+00  0.9807910131886349303088E+00  0.5517350488583738776782E-01 -0.1870958920100168898504E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           438                             0                             0                             0                             0                             0                             0
 -0.4654650745130819999851E+00 -0.8350873084007630342551E-01  0.4965845802811857390147E+00  0.9965065162337798376768E+00  0.5517350488583738776782E-01 -0.6269487588494175589471E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           439                             0                             0                             0                             0                             0                             0
 -0.4654650745130819999851E+00 -0.8350873084007630342551E-01  0.4380154197188143583297E+00  0.9965065162337798376768E+00  0.5517350488583738776782E-01  0.6269487588494151997232E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           440                             0                             0                             0                             0                             0                             0
 -0.4581244122326530443523E+00 -0.8350873084007630342551E-01  0.3799080944812371907204E+00  0.9807910131886349303088E+00  0.5517350488583738776782E-01  0.1870958920100166400502E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           441                             0                             0                             0                             0                             0                             0
 -0.4435588543010565709679E+00 -0.8350873084007630342551E-01  0.3231789917990848248763E+00  0.9496078499693533236936E+00  0.5517350488583738776782E-01  0.3085462941524254043557E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           442                             0                             0                             0                             0                             0                             0
 -0.4219981082679165607097E+00 -0.8350873084007630342551E-01  0.2687227635099783684680E+00  0.9034488036878223216064E+00  0.5517350488583738776782E-01  0.4251307369194276541968E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           443                             0                             0                             0                             0                             0                             0
 -0.3937821999779405057751E+00 -0.8350873084007630342551E-01  0.2173982168646100554543E+00  0.8430418300779781715093E+00  0.5517350488583738082893E-01  0.5350106140044197378103E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           444                             0                             0                             0                             0                             0                             0
 -0.3593561111602286972655E+00 -0.8350873084007630342551E-01  0.1700147706233766653483E+00  0.7693395831990267330625E+00  0.5517350488583738776782E-01  0.6364530541067114910447E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           445                             0                             0                             0                             0                             0                             0
 -0.3192627618005844380988E+00 -0.8350873084007630342551E-01  0.1273196900390001773395E+00  0.6835043915118359514338E+00  0.5517350488583738776782E-01  0.7278582493471155157039E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           446                             0                             0                             0                             0                             0                             0
 -0.2741344479690154822826E+00 -0.8350873084007630342551E-01  0.8998630203710156205688E-01  0.5868899272647711828910E+00  0.5517350488583738776782E-01  0.8077846851938729200171E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           447                             0                             0                             0                             0                             0                             0
 -0.2246828701329940669584E+00 -0.8350873084007630342551E-01  0.5860337644835589276937E-01  0.4810198582736930905668E+00  0.5517350488583738776782E-01  0.8749718740079414081023E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           448                             0                             0                             0                             0                             0                             0
 -0.1716879092159338260348E+00 -0.8350873084007630342551E-01  0.3366584075654804886213E-01  0.3675638187703021975139E+00  0.5517350488583738776782E-01  0.9283602336860434789401E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           449                             0                             0                             0                             0                             0                             0
 -0.1159853274091534186541E+00 -0.8350873084007630342551E-01  0.1556697479650032134302E-01  0.2483110782729229526478E+00  0.5517350488583738776782E-01  0.9671077979033935179132E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           450                             0                             0                             0                             0                             0                             0
 -0.5845358770285412342016E-01 -0.8350873084007630342551E-01  0.4592208496140726126100E-02  0.1251423237373307240095E+00  0.5517350488583738776782E-01  0.9906034944256122409811E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           451                             0                             0                             0                             0                             0                             0
  0.2857202088189609859734E-16 -0.6263164564168170744818E-01  0.6834881732585285085690E-03 -0.6123157930625321031066E-16  0.4984435425738802452611E-02  0.9999875776245855663049E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           452                             0                             0                             0                             0                             0                             0
  0.5848255626174192478572E-01 -0.6263164564168170744818E-01  0.4362898740608855963075E-02 -0.1253316766278250171673E+00  0.4984435425738803319973E-02  0.9921023768932040187707E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           453                             0                             0                             0                             0                             0                             0
  0.1160428076754504433943E+00 -0.6263164564168170744818E-01  0.1534310394003945976493E-01 -0.2486867978457145966775E+00  0.4984435425738802452611E-02  0.9685711290249834348742E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           454                             0                             0                             0                             0                             0                             0
  0.1717729946915040051270E+00 -0.6263164564168170744818E-01  0.3345093937629861624572E-01 -0.3681199797032853604506E+00  0.4984435425738801585249E-02  0.9297649358556920873298E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           455                             0                             0                             0                             0                             0                             0
  0.2247942189690592118545E+00 -0.6263164564168170744818E-01  0.5840083366745996151792E-01 -0.4817476895767183742159E+00  0.4984435425738803319973E-02  0.8762957942333059468965E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           456                             0                             0                             0                             0                             0                             0
  0.2742703041279150322218E+00 -0.6263164564168170744818E-01  0.8979931207620750477361E-01 -0.5877779506034060963415E+00  0.4984435425738802452611E-02  0.8090069444621266203654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           457                             0                             0                             0                             0                             0                             0
  0.3194209827495355646931E+00 -0.6263164564168170744818E-01  0.1271512018414934219734E+00 -0.6845386022275499193768E+00  0.4984435425738802452611E-02  0.7289595718994563711135E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           458                             0                             0                             0                             0                             0                             0
  0.3595342016603499946115E+00 -0.6263164564168170744818E-01  0.1698674413487818446455E+00 -0.7705036711710256946972E+00  0.4984435425738802452611E-02  0.6374160714285908024834E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           459                             0                             0                             0                             0                             0                             0
  0.3939773514356591510577E+00 -0.6263164564168170744818E-01  0.2172743699835980590862E+00 -0.8443174369435516579685E+00  0.4984435425738802452611E-02  0.5358201387373922042201E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           460                             0                             0                             0                             0                             0                             0
  0.4222072430281660349038E+00 -0.6263164564168170744818E-01  0.2686243521618446594701E+00 -0.9048158123646886652480E+00  0.4984435425738803319973E-02  0.4257740023748690649796E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           461                             0                             0                             0                             0                             0                             0
  0.4437786741837370652064E+00 -0.6263164564168170744818E-01  0.3231075679895782926110E+00 -0.9510447019140677582527E+00  0.4984435425738801585249E-02  0.3090131556498338372130E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           462                             0                             0                             0                             0                             0                             0
  0.4583514505469005184679E+00 -0.6263164564168170744818E-01  0.3798647846064998612192E+00 -0.9822750483876953042639E+00  0.4984435425738802452611E-02  0.1873789868646892342596E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           463                             0                             0                             0                             0                             0                             0
  0.4656957507290546693923E+00 -0.6263164564168170744818E-01  0.4380009068014428796900E+00 -0.9980143305655774232932E+00  0.4984435425738802452611E-02  0.6278973952190740337453E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           464                             0                             0                             0                             0                             0                             0
  0.4656957507290546693923E+00 -0.6263164564168170744818E-01  0.4965990931985571066321E+00 -0.9980143305655774232932E+00  0.4984435425738802452611E-02 -0.6278973952190740337453E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           465                             0                             0                             0                             0                             0                             0
  0.4583514505469005184679E+00 -0.6263164564168170744818E-01  0.5547352153935001251028E+00 -0.9822750483876953042639E+00  0.4984435425738802452611E-02 -0.1873789868646892342596E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           466                             0                             0                             0                             0                             0                             0
  0.4437786741837371207176E+00 -0.6263164564168170744818E-01  0.6114924320104215826888E+00 -0.9510447019140678692750E+00  0.4984435425738802452611E-02 -0.3090131556498336151684E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           467                             0                             0                             0                             0                             0                             0
  0.4222072430281659793927E+00 -0.6263164564168170744818E-01  0.6659756478381553268520E+00 -0.9048158123646885542257E+00  0.4984435425738801585249E-02 -0.4257740023748692315131E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           468                             0                             0                             0                             0                             0                             0
  0.3939773514356589845242E+00 -0.6263164564168170744818E-01  0.7173256300164020382581E+00 -0.8443174369435513249016E+00  0.4984435425738802452611E-02 -0.5358201387373925372870E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           469                             0                             0                             0                             0                             0                             0
  0.3595342016603499391003E+00 -0.6263164564168170744818E-01  0.7647325586512181416765E+00 -0.7705036711710255836749E+00  0.4984435425738801585249E-02 -0.6374160714285909135057E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           470                             0                             0                             0                             0                             0                             0
  0.3194209827495356757154E+00 -0.6263164564168170744818E-01  0.8074487981585064533263E+00 -0.6845386022275501414214E+00  0.4984435425738802452611E-02 -0.7289595718994561490689E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           471                             0                             0                             0                             0                             0                             0
  0.2742703041279150322218E+00 -0.6263164564168170744818E-01  0.8448006879237924815484E+00 -0.5877779506034060963415E+00  0.4984435425738802452611E-02 -0.8090069444621266203654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           472                             0                             0                             0                             0                             0                             0
  0.2247942189690591285878E+00 -0.6263164564168170744818E-01  0.8761991663325401358264E+00 -0.4817476895767182076824E+00  0.4984435425738802452611E-02 -0.8762957942333060579188E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           473                             0                             0                             0                             0                             0                             0
  0.1717729946915040051270E+00 -0.6263164564168170744818E-01  0.9011490606237013700763E+00 -0.3681199797032853604506E+00  0.4984435425738801585249E-02 -0.9297649358556920873298E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           474                             0                             0                             0                             0                             0                             0
  0.1160428076754506515611E+00 -0.6263164564168170744818E-01  0.9192568960599605265571E+00 -0.2486867978457150407667E+00  0.4984435425738802452611E-02 -0.9685711290249833238519E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           475                             0                             0                             0                             0                             0                             0
  0.5848255626174202886913E-01 -0.6263164564168170744818E-01  0.9302371012593910748478E+00 -0.1253316766278252392119E+00  0.4984435425738801585249E-02 -0.9921023768932039077484E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           476                             0                             0                             0                             0                             0                             0
  0.2857202088189609859734E-16 -0.6263164564168170744818E-01  0.9339165118267414023023E+00 -0.6123157930625321031066E-16  0.4984435425738802452611E-02 -0.9999875776245855663049E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
