 -0.8364824532290297820492E-01 -0.1354477621473950677000E+00  0.7930884057987965807257E+00 -0.8325129508193870875310E-01  0.9423036116584815324870E+00  0.3242423866840383750443E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           129                             0                             0                             0                             0                             0                             0
 -0.1238207682805350096089E+00 -0.1354477621473950677000E+00  0.7800355618424933412669E+00 -0.1232331805359791754295E+00  0.9423036116584814214647E+00  0.3112514846074926899711E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           130                             0                             0                             0                             0                             0                             0
 -0.1620405637554413469381E+00 -0.1354477621473950677000E+00  0.7620506912567648338808E+00 -0.1612716051170334785603E+00  0.9423036116584815324870E+00  0.2933519606860623962774E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           131                             0                             0                             0                             0                             0                             0
 -0.1977048827415833209820E+00 -0.1354477621473950677000E+00  0.7394174261943888826210E+00 -0.1967666801464047487968E+00  0.9423036116584815324870E+00  0.2708261011046459998397E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           132                             0                             0                             0                             0                             0                             0
 -0.2302512776237185254669E+00 -0.1354477621473950677000E+00  0.7124927067658564094899E+00 -0.2291586270871502628577E+00  0.9423036116584815324870E+00  0.2440291521251383155544E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           133                             0                             0                             0                             0                             0                             0
 -0.2591664723122815705558E+00 -0.1354477621473950677000E+00  0.6817011518806027625672E+00 -0.2579366055860031203828E+00  0.9423036116584815324870E+00  0.2133837176406676028328E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           134                             0                             0                             0                             0                             0                             0
 -0.2839944569139336016939E+00 -0.1354477621473950677000E+00  0.6475283627531521757348E+00 -0.2826467697309051341215E+00  0.9423036116584815324870E+00  0.1793730944597494159076E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           135                             0                             0                             0                             0                             0                             0
 -0.3043436792799876222659E+00 -0.1354477621473950677000E+00  0.6105132646818791641863E+00 -0.3028994254721547596532E+00  0.9423036116584815324870E+00  0.1425336504269082149587E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           136                             0                             0                             0                             0                             0                             0
 -0.3198932200176945461756E+00 -0.1354477621473950677000E+00  0.5712396078751156291986E+00 -0.3183751763303622195345E+00  0.9423036116584816435093E+00  0.1034463655813593202515E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           137                             0                             0                             0                             0                             0                             0
 -0.3303978535807756689024E+00 -0.1354477621473950677000E+00  0.5303267613616491349404E+00 -0.3288299604697284550525E+00  0.9423036116584816435093E+00  0.6272766975472869599439E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           138                             0                             0                             0                             0                             0                             0
 -0.3356919156227770595358E+00 -0.1354477621473950677000E+00  0.4884199451711471740012E+00 -0.3340988996989901482770E+00  0.9423036116584815324870E+00  0.2101972110437239082970E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           139                             0                             0                             0                             0                             0                             0
 -0.3356919156227770595358E+00 -0.1354477621473950677000E+00  0.4461800548288528678320E+00 -0.3340988996989901482770E+00  0.9423036116584814214647E+00 -0.2101972110437231450186E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           140                             0                             0                             0                             0                             0                             0
 -0.3303978535807756689024E+00 -0.1354477621473950677000E+00  0.4042732386383509624039E+00 -0.3288299604697284550525E+00  0.9423036116584815324870E+00 -0.6272766975472861272767E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           141                             0                             0                             0                             0                             0                             0
 -0.3198932200176946016867E+00 -0.1354477621473950677000E+00  0.3633603921248844681458E+00 -0.3183751763303622750456E+00  0.9423036116584815324870E+00 -0.1034463655813592508625E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           142                             0                             0                             0                             0                             0                             0
 -0.3043436792799876222659E+00 -0.1354477621473950677000E+00  0.3240867353181209331581E+00 -0.3028994254721547596532E+00  0.9423036116584815324870E+00 -0.1425336504269081316920E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           143                             0                             0                             0                             0                             0                             0
 -0.2839944569139334906716E+00 -0.1354477621473950677000E+00  0.2870716372468475885427E+00 -0.2826467697309050230992E+00  0.9423036116584815324870E+00 -0.1793730944597495824411E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           144                             0                             0                             0                             0                             0                             0
 -0.2591664723122816260670E+00 -0.1354477621473950677000E+00  0.2528988481193972237548E+00 -0.2579366055860031758939E+00  0.9423036116584815324870E+00 -0.2133837176406675473217E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           145                             0                             0                             0                             0                             0                             0
 -0.2302512776237186920003E+00 -0.1354477621473950677000E+00  0.2221072932341437711212E+00 -0.2291586270871504293911E+00  0.9423036116584815324870E+00 -0.2440291521251381767765E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           146                             0                             0                             0                             0                             0                             0
 -0.1977048827415835152710E+00 -0.1354477621473950677000E+00  0.1951825738056111592122E+00 -0.1967666801464049430859E+00  0.9423036116584815324870E+00 -0.2708261011046458888174E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           147                             0                             0                             0                             0                             0                             0
 -0.1620405637554415412271E+00 -0.1354477621473950677000E+00  0.1725493087432353189747E+00 -0.1612716051170336728493E+00  0.9423036116584815324870E+00 -0.2933519606860622852551E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           148                             0                             0                             0                             0                             0                             0
 -0.1238207682805349540978E+00 -0.1354477621473950677000E+00  0.1545644381575066450552E+00 -0.1232331805359791199184E+00  0.9423036116584815324870E+00 -0.3112514846074926899711E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           149                             0                             0                             0                             0                             0                             0
 -0.8364824532290320024952E-01 -0.1354477621473950677000E+00  0.1415115942012034611075E+00 -0.8325129508193893079770E-01  0.9423036116584814214647E+00 -0.3242423866840383195331E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           150                             0                             0                             0                             0                             0                             0
 -0.4215653956748931924237E-01 -0.1354477621473950677000E+00  0.1335966280209074374952E+00 -0.4195648697254322073702E-01  0.9423036116584815324870E+00 -0.3321197926295635372007E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           151                             0                             0                             0                             0                             0                             0
  0.2267905928947921885226E-16 -0.1454899278762296632728E+00  0.9692285443820597423681E-01  0.1339179472829765431407E-16  0.9757911127481381230453E+00 -0.2187046050766889293548E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           152                             0                             0                             0                             0                             0                             0
  0.4642056529157664868102E-01 -0.1454899278762296632728E+00  0.9984338885725180245956E-01  0.2741095534966557500933E-01  0.9757911127481382340676E+00 -0.2169800539417600926395E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           153                             0                             0                             0                             0                             0                             0
  0.9210905053820353516336E-01 -0.1454899278762296632728E+00  0.1085589335419583911779E+00  0.5438962355895588657306E-01  0.9757911127481380120230E+00 -0.2118335977385682189489E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           154                             0                             0                             0                             0                             0                             0
  0.1363449210345633322294E+00 -0.1454899278762296632728E+00  0.1229320391462337958011E+00  0.8051053491393528327436E-01  0.9757911127481382340676E+00 -0.2033463991557816485933E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           155                             0                             0                             0                             0                             0                             0
  0.1784305506777000838170E+00 -0.1454899278762296632728E+00  0.1427360332086214933511E+00  0.1053617470386595533771E+00  0.9757911127481382340676E+00 -0.1916523063850575914202E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           156                             0                             0                             0                             0                             0                             0
  0.2177022239474051545916E+00 -0.1454899278762296632728E+00  0.1676585949124249630415E+00  0.1285513414725273084738E+00  0.9757911127481382340676E+00 -0.1769357422551027514412E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           157                             0                             0                             0                             0                             0                             0
  0.2535406030964547086093E+00 -0.1454899278762296632728E+00  0.1973066805715586458092E+00  0.1497136044585241909655E+00  0.9757911127481380120230E+00 -0.1594287957734958072198E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           158                             0                             0                             0                             0                             0                             0
  0.2853804954768584534186E+00 -0.1454899278762296632728E+00  0.2312127221642700791726E+00  0.1685147944676379239137E+00  0.9757911127481380120230E+00 -0.1394075619443945757148E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           159                             0                             0                             0                             0                             0                             0
  0.3127197669655474299155E+00 -0.1454899278762296632728E+00  0.2688420011601546644187E+00  0.1846584055021382730910E+00  0.9757911127481382340676E+00 -0.1171877875853894052094E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           160                             0                             0                             0                             0                             0                             0
  0.3351272609194559937151E+00 -0.1454899278762296632728E+00  0.3096010813508055514731E+00  0.1978898431722853068493E+00  0.9757911127481382340676E+00 -0.9311989181157159789493E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           161                             0                             0                             0                             0                             0                             0
  0.3522495977733428040857E+00 -0.1454899278762296632728E+00  0.3528471676933220280148E+00  0.2080004398019431322009E+00  0.9757911127481381230453E+00 -0.6758343971675827288603E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           162                             0                             0                             0                             0                             0                             0
  0.3638167480466339975820E+00 -0.1454899278762296632728E+00  0.3978982435721227228775E+00  0.2148307452424843833061E+00  0.9757911127481382340676E+00 -0.4098115640522172198335E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           163                             0                             0                             0                             0                             0                             0
  0.3696462908696390159413E+00 -0.1454899278762296632728E+00  0.4440438266083908125381E+00  0.2182730414968850063406E+00  0.9757911127481381230453E+00 -0.1373257577621862270123E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           164                             0                             0                             0                             0                             0                             0
  0.3696462908696390159413E+00 -0.1454899278762296632728E+00  0.4905561733916091737839E+00  0.2182730414968850063406E+00  0.9757911127481381230453E+00  0.1373257577621862270123E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           165                             0                             0                             0                             0                             0                             0
  0.3638167480466339975820E+00 -0.1454899278762296632728E+00  0.5367017564278772079334E+00  0.2148307452424843833061E+00  0.9757911127481382340676E+00  0.4098115640522172198335E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           166                             0                             0                             0                             0                             0                             0
  0.3522495977733428595968E+00 -0.1454899278762296632728E+00  0.5817528323066778472850E+00  0.2080004398019431599565E+00  0.9757911127481381230453E+00  0.6758343971675823125267E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           167                             0                             0                             0                             0                             0                             0
  0.3351272609194559382040E+00 -0.1454899278762296632728E+00  0.6249989186491944348489E+00  0.1978898431722852790937E+00  0.9757911127481382340676E+00  0.9311989181157162565050E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           168                             0                             0                             0                             0                             0                             0
  0.3127197669655473188932E+00 -0.1454899278762296632728E+00  0.6657579988398454329257E+00  0.1846584055021381898243E+00  0.9757911127481380120230E+00  0.1171877875853894745983E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           169                             0                             0                             0                             0                             0                             0
  0.2853804954768583979074E+00 -0.1454899278762296632728E+00  0.7033872778357299626606E+00  0.1685147944676378961582E+00  0.9757911127481380120230E+00  0.1394075619443946034703E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           170                             0                             0                             0                             0                             0                             0
  0.2535406030964548196316E+00 -0.1454899278762296632728E+00  0.7372933194284412294905E+00  0.1497136044585242464766E+00  0.9757911127481380120230E+00  0.1594287957734957517086E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           171                             0                             0                             0                             0                             0                             0
  0.2177022239474051545916E+00 -0.1454899278762296632728E+00  0.7669414050875750232805E+00  0.1285513414725273084738E+00  0.9757911127481382340676E+00  0.1769357422551027514412E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           172                             0                             0                             0                             0                             0                             0
  0.1784305506777000283058E+00 -0.1454899278762296632728E+00  0.7918639667913784929709E+00  0.1053617470386595117438E+00  0.9757911127481382340676E+00  0.1916523063850576191758E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           173                             0                             0                             0                             0                             0                             0
  0.1363449210345633322294E+00 -0.1454899278762296632728E+00  0.8116679608537662460321E+00  0.8051053491393528327436E-01  0.9757911127481382340676E+00  0.2033463991557816485933E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           174                             0                             0                             0                             0                             0                             0
  0.9210905053820370169682E-01 -0.1454899278762296632728E+00  0.8260410664580415396330E+00  0.5438962355895598371758E-01  0.9757911127481380120230E+00  0.2118335977385681911933E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           175                             0                             0                             0                             0                             0                             0
  0.4642056529157672500885E-01 -0.1454899278762296632728E+00  0.8347566111427481283513E+00  0.2741095534966562358159E-01  0.9757911127481381230453E+00  0.2169800539417600648839E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           176                             0                             0                             0                             0                             0                             0
  0.2267905928947921885226E-16 -0.1454899278762296632728E+00  0.8376771455617939565741E+00  0.1339179472829765431407E-16  0.9757911127481381230453E+00  0.2187046050766889293548E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           177                             0                             0                             0                             0                             0                             0
 -0.4642056529157669031438E-01 -0.1454899278762296632728E+00  0.8347566111427481283513E+00 -0.2741095534966559929546E-01  0.9757911127481381230453E+00  0.2169800539417600648839E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           178                             0                             0                             0                             0                             0                             0
 -0.9210905053820349353000E-01 -0.1454899278762296632728E+00  0.8260410664580415396330E+00 -0.5438962355895586575638E-01  0.9757911127481381230453E+00  0.2118335977385682467045E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           179                             0                             0                             0                             0                             0                             0
 -0.1363449210345632767183E+00 -0.1454899278762296632728E+00  0.8116679608537662460321E+00 -0.8051053491393526939657E-01  0.9757911127481381230453E+00  0.2033463991557816485933E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           180                             0                             0                             0                             0                             0                             0
 -0.1784305506777001393282E+00 -0.1454899278762296632728E+00  0.7918639667913784929709E+00 -0.1053617470386595811327E+00  0.9757911127481381230453E+00  0.1916523063850575636646E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           181                             0                             0                             0                             0                             0                             0
 -0.2177022239474049880581E+00 -0.1454899278762296632728E+00  0.7669414050875751343028E+00 -0.1285513414725271974515E+00  0.9757911127481382340676E+00  0.1769357422551028347080E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           182                             0                             0                             0                             0                             0                             0
 -0.2535406030964546530981E+00 -0.1454899278762296632728E+00  0.7372933194284414515352E+00 -0.1497136044585241354543E+00  0.9757911127481381230453E+00  0.1594287957734958627309E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           183                             0                             0                             0                             0                             0                             0
 -0.2853804954768584534186E+00 -0.1454899278762296632728E+00  0.7033872778357298516383E+00 -0.1685147944676379516693E+00  0.9757911127481380120230E+00  0.1394075619443945479592E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           184                             0                             0                             0                             0                             0                             0
 -0.3127197669655474854267E+00 -0.1454899278762296632728E+00  0.6657579988398452108811E+00 -0.1846584055021382730910E+00  0.9757911127481380120230E+00  0.1171877875853893358205E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           185                             0                             0                             0                             0                             0                             0
 -0.3351272609194560492263E+00 -0.1454899278762296632728E+00  0.6249989186491942128043E+00 -0.1978898431722853623604E+00  0.9757911127481381230453E+00  0.9311989181157148687262E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           186                             0                             0                             0                             0                             0                             0
 -0.3522495977733428040857E+00 -0.1454899278762296632728E+00  0.5817528323066780693296E+00 -0.2080004398019431322009E+00  0.9757911127481381230453E+00  0.6758343971675830064161E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           187                             0                             0                             0                             0                             0                             0
 -0.3638167480466339975820E+00 -0.1454899278762296632728E+00  0.5367017564278772079334E+00 -0.2148307452424843833061E+00  0.9757911127481382340676E+00  0.4098115640522170116666E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           188                             0                             0                             0                             0                             0                             0
 -0.3696462908696390159413E+00 -0.1454899278762296632728E+00  0.4905561733916090627616E+00 -0.2182730414968850063406E+00  0.9757911127481381230453E+00  0.1373257577621855331229E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           189                             0                             0                             0                             0                             0                             0
 -0.3696462908696390159413E+00 -0.1454899278762296632728E+00  0.4440438266083909790716E+00 -0.2182730414968850063406E+00  0.9757911127481381230453E+00 -0.1373257577621850127059E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           190                             0                             0                             0                             0                             0                             0
 -0.3638167480466339975820E+00 -0.1454899278762296632728E+00  0.3978982435721228894110E+00 -0.2148307452424843833061E+00  0.9757911127481381230453E+00 -0.4098115640522165259441E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           191                             0                             0                             0                             0                             0                             0
 -0.3522495977733428595968E+00 -0.1454899278762296632728E+00  0.3528471676933220280148E+00 -0.2080004398019431599565E+00  0.9757911127481381230453E+00 -0.6758343971675824513046E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           192                             0                             0                             0                             0                             0                             0
 -0.3351272609194561047374E+00 -0.1454899278762296632728E+00  0.3096010813508058290289E+00 -0.1978898431722853901160E+00  0.9757911127481382340676E+00 -0.9311989181157143136147E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           193                             0                             0                             0                             0                             0                             0
 -0.3127197669655473744044E+00 -0.1454899278762296632728E+00  0.2688420011601545533964E+00 -0.1846584055021382175799E+00  0.9757911127481380120230E+00 -0.1171877875853894607205E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           194                             0                             0                             0                             0                             0                             0
 -0.2853804954768585644409E+00 -0.1454899278762296632728E+00  0.2312127221642701901949E+00 -0.1685147944676380071805E+00  0.9757911127481381230453E+00 -0.1394075619443944924480E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           195                             0                             0                             0                             0                             0                             0
 -0.2535406030964548751427E+00 -0.1454899278762296632728E+00  0.1973066805715587568315E+00 -0.1497136044585242464766E+00  0.9757911127481382340676E+00 -0.1594287957734957517086E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           196                             0                             0                             0                             0                             0                             0
 -0.2177022239474051823471E+00 -0.1454899278762296632728E+00  0.1676585949124250185527E+00 -0.1285513414725273362293E+00  0.9757911127481380120230E+00 -0.1769357422551027236857E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           197                             0                             0                             0                             0                             0                             0
 -0.1784305506777003613728E+00 -0.1454899278762296632728E+00  0.1427360332086216598846E+00 -0.1053617470386597060328E+00  0.9757911127481381230453E+00 -0.1916523063850574803979E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           198                             0                             0                             0                             0                             0                             0
 -0.1363449210345632212071E+00 -0.1454899278762296632728E+00  0.1229320391462337402899E+00 -0.8051053491393522776320E-01  0.9757911127481381230453E+00 -0.2033463991557816763489E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           199                             0                             0                             0                             0                             0                             0
 -0.9210905053820374333018E-01 -0.1454899278762296632728E+00  0.1085589335419584466891E+00 -0.5438962355895601147315E-01  0.9757911127481381230453E+00 -0.2118335977385681911933E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           200                             0                             0                             0                             0                             0                             0
 -0.4642056529157676664221E-01 -0.1454899278762296632728E+00  0.9984338885725185797071E-01 -0.2741095534966564786772E-01  0.9757911127481381230453E+00 -0.2169800539417600648839E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           201                             0                             0                             0                             0                             0                             0
  0.2478447034988451742687E-16 -0.1500082858934205787271E+00  0.6253888247386213405932E-01  0.1492889658186007431175E-17  0.9997027456190183958284E+00 -0.2438073833574570803417E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           202                             0                             0                             0                             0                             0                             0
  0.5073001968065224409621E-01 -0.1500082858934205787271E+00  0.6573054478184148230469E-01  0.3055716772304203649596E-02  0.9997027456190185068508E+00 -0.2418848893179479514481E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           203                             0                             0                             0                             0                             0                             0
  0.1006599966462957268520E+00 -0.1500082858934205787271E+00  0.7525519728457602530725E-01  0.6063243065712448781612E-02  0.9997027456190183958284E+00 -0.2361477260788657703272E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           204                             0                             0                             0                             0                             0                             0
  0.1490025053334599058896E+00 -0.1500082858934205787271E+00  0.9096263052234604407076E-01  0.8975148393968571808310E-02  0.9997027456190183958284E+00 -0.2266863721317061847182E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           205                             0                             0                             0                             0                             0                             0
  0.1949951555017331028541E+00 -0.1500082858934205787271E+00  0.1126051288898260449578E+00  0.1174551027055803498200E-01  0.9997027456190185068508E+00 -0.2136500386801547246574E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           206                             0                             0                             0                             0                             0                             0
  0.2379126155832843036997E+00 -0.1500082858934205787271E+00  0.1398413772591590720218E+00  0.1433063843375306269101E-01  0.9997027456190185068508E+00 -0.1972443164902705145525E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           207                             0                             0                             0                             0                             0                             0
  0.2770780515949795019814E+00 -0.1500082858934205787271E+00  0.1722418437234146115777E+00  0.1668976386813935536280E-01  0.9997027456190183958284E+00 -0.1777279336012914032206E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           208                             0                             0                             0                             0                             0                             0
  0.3118738012146168303573E+00 -0.1500082858934205787271E+00  0.2092955535713509340745E+00  0.1878568175634342390934E-01  0.9997027456190181737838E+00 -0.1554086750298985623864E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           209                             0                             0                             0                             0                             0                             0
  0.3417511146847213576727E+00 -0.1500082858934205787271E+00  0.2504181476638526193668E+00  0.2058533822122762813045E-01  0.9997027456190185068508E+00 -0.1306385288166417649180E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           210                             0                             0                             0                             0                             0                             0
  0.3662388089240274369196E+00 -0.1500082858934205787271E+00  0.2949610981266339582163E+00  0.2206035160527807653663E-01  0.9997027456190185068508E+00 -0.1038081349642721445958E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           211                             0                             0                             0                             0                             0                             0
  0.3849506983661418746401E+00 -0.1500082858934205787271E+00  0.3422219360222280570838E+00  0.2318746006629801223453E-01  0.9997027456190182848061E+00 -0.7534062481154195703437E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           212                             0                             0                             0                             0                             0                             0
  0.3975916853366216474619E+00 -0.1500082858934205787271E+00  0.3914553297047652646867E+00  0.2394888843055519717096E-01  0.9997027456190185068508E+00 -0.4568494799922603183395E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           213                             0                             0                             0                             0                             0                             0
  0.4039624139195824858994E+00 -0.1500082858934205787271E+00  0.4418848391452682711211E+00  0.2433262851789003144987E-01  0.9997027456190183958284E+00 -0.1530879226609722053298E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           214                             0                             0                             0                             0                             0                             0
  0.4039624139195824858994E+00 -0.1500082858934205787271E+00  0.4927151608547317152009E+00  0.2433262851789003144987E-01  0.9997027456190183958284E+00  0.1530879226609722053298E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           215                             0                             0                             0                             0                             0                             0
  0.3975916853366216474619E+00 -0.1500082858934205787271E+00  0.5431446702952347216353E+00  0.2394888843055519717096E-01  0.9997027456190185068508E+00  0.4568494799922603183395E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           216                             0                             0                             0                             0                             0                             0
  0.3849506983661419301512E+00 -0.1500082858934205787271E+00  0.5923780639777718182160E+00  0.2318746006629801570398E-01  0.9997027456190183958284E+00  0.7534062481154190499266E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           217                             0                             0                             0                             0                             0                             0
  0.3662388089240274369196E+00 -0.1500082858934205787271E+00  0.6396389018733661391281E+00  0.2206035160527807306718E-01  0.9997027456190183958284E+00  0.1038081349642721966375E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           218                             0                             0                             0                             0                             0                             0
  0.3417511146847211911393E+00 -0.1500082858934205787271E+00  0.6841818523361475889999E+00  0.2058533822122762119156E-01  0.9997027456190183958284E+00  0.1306385288166418516542E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           219                             0                             0                             0                             0                             0                             0
  0.3118738012146167748462E+00 -0.1500082858934205787271E+00  0.7253044464286491077587E+00  0.1878568175634342043989E-01  0.9997027456190182848061E+00  0.1554086750298985970808E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           220                             0                             0                             0                             0                             0                             0
  0.2770780515949795574926E+00 -0.1500082858934205787271E+00  0.7623581562765853192332E+00  0.1668976386813936230169E-01  0.9997027456190183958284E+00  0.1777279336012913338316E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           221                             0                             0                             0                             0                             0                             0
  0.2379126155832843036997E+00 -0.1500082858934205787271E+00  0.7947586227408409698114E+00  0.1433063843375306269101E-01  0.9997027456190185068508E+00  0.1972443164902705145525E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           222                             0                             0                             0                             0                             0                             0
  0.1949951555017330473429E+00 -0.1500082858934205787271E+00  0.8219948711101739968754E+00  0.1174551027055803151256E-01  0.9997027456190183958284E+00  0.2136500386801547593518E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           223                             0                             0                             0                             0                             0                             0
  0.1490025053334599058896E+00 -0.1500082858934205787271E+00  0.8436373694776539977624E+00  0.8975148393968571808310E-02  0.9997027456190183958284E+00  0.2266863721317061847182E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           224                             0                             0                             0                             0                             0                             0
  0.1006599966462959072633E+00 -0.1500082858934205787271E+00  0.8593448027154239055037E+00  0.6063243065712459189953E-02  0.9997027456190183958284E+00  0.2361477260788657356327E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           225                             0                             0                             0                             0                             0                             0
  0.5073001968065233430183E-01 -0.1500082858934205787271E+00  0.8688694552181585040174E+00  0.3055716772304208853767E-02  0.9997027456190183958284E+00  0.2418848893179479167537E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           226                             0                             0                             0                             0                             0                             0
  0.2478447034988451742687E-16 -0.1500082858934205787271E+00  0.8720611175261379077739E+00  0.1492889658186007431175E-17  0.9997027456190183958284E+00  0.2438073833574570803417E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           227                             0                             0                             0                             0                             0                             0
 -0.5073001968065228572957E-01 -0.1500082858934205787271E+00  0.8688694552181585040174E+00 -0.3055716772304206251681E-02  0.9997027456190182848061E+00  0.2418848893179479167537E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           228                             0                             0                             0                             0                             0                             0
 -0.1006599966462956852187E+00 -0.1500082858934205787271E+00  0.8593448027154240165260E+00 -0.6063243065712446179527E-02  0.9997027456190185068508E+00  0.2361477260788658050217E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           229                             0                             0                             0                             0                             0                             0
 -0.1490025053334598781341E+00 -0.1500082858934205787271E+00  0.8436373694776539977624E+00 -0.8975148393968568338863E-02  0.9997027456190182848061E+00  0.2266863721317061847182E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           230                             0                             0                             0                             0                             0                             0
 -0.1949951555017331583652E+00 -0.1500082858934205787271E+00  0.8219948711101738858531E+00 -0.1174551027055803845145E-01  0.9997027456190183958284E+00  0.2136500386801546899629E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           231                             0                             0                             0                             0                             0                             0
 -0.2379126155832841371662E+00 -0.1500082858934205787271E+00  0.7947586227408409698114E+00 -0.1433063843375305228267E-01  0.9997027456190186178731E+00  0.1972443164902705839414E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           232                             0                             0                             0                             0                             0                             0
 -0.2770780515949793909591E+00 -0.1500082858934205787271E+00  0.7623581562765854302555E+00 -0.1668976386813935189335E-01  0.9997027456190183958284E+00  0.1777279336012914379150E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           233                             0                             0                             0                             0                             0                             0
 -0.3118738012146168858685E+00 -0.1500082858934205787271E+00  0.7253044464286489967364E+00 -0.1878568175634342737879E-01  0.9997027456190183958284E+00  0.1554086750298985450391E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           234                             0                             0                             0                             0                             0                             0
 -0.3417511146847213576727E+00 -0.1500082858934205787271E+00  0.6841818523361472559330E+00 -0.2058533822122763159990E-01  0.9997027456190183958284E+00  0.1306385288166416955291E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           235                             0                             0                             0                             0                             0                             0
 -0.3662388089240275479419E+00 -0.1500082858934205787271E+00  0.6396389018733659170834E+00 -0.2206035160527808347553E-01  0.9997027456190183958284E+00  0.1038081349642720231652E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           236                             0                             0                             0                             0                             0                             0
 -0.3849506983661418746401E+00 -0.1500082858934205787271E+00  0.5923780639777720402606E+00 -0.2318746006629801223453E-01  0.9997027456190183958284E+00  0.7534062481154198305522E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           237                             0                             0                             0                             0                             0                             0
 -0.3975916853366216474619E+00 -0.1500082858934205787271E+00  0.5431446702952347216353E+00 -0.2394888843055519717096E-01  0.9997027456190185068508E+00  0.4568494799922601448672E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           238                             0                             0                             0                             0                             0                             0
 -0.4039624139195824858994E+00 -0.1500082858934205787271E+00  0.4927151608547315486675E+00 -0.2433262851789003144987E-01  0.9997027456190183958284E+00  0.1530879226609714463883E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           239                             0                             0                             0                             0                             0                             0
 -0.4039624139195824858994E+00 -0.1500082858934205787271E+00  0.4418848391452684931657E+00 -0.2433262851789003144987E-01  0.9997027456190183958284E+00 -0.1530879226609708609191E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           240                             0                             0                             0                             0                             0                             0
 -0.3975916853366216474619E+00 -0.1500082858934205787271E+00  0.3914553297047654312202E+00 -0.2394888843055519717096E-01  0.9997027456190183958284E+00 -0.4568494799922595377140E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           241                             0                             0                             0                             0                             0                             0
 -0.3849506983661419301512E+00 -0.1500082858934205787271E+00  0.3422219360222280570838E+00 -0.2318746006629801570398E-01  0.9997027456190183958284E+00 -0.7534062481154193101351E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           242                             0                             0                             0                             0                             0                             0
 -0.3662388089240276034531E+00 -0.1500082858934205787271E+00  0.2949610981266341802609E+00 -0.2206035160527808347553E-01  0.9997027456190183958284E+00 -0.1038081349642719711235E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           243                             0                             0                             0                             0                             0                             0
 -0.3417511146847212466504E+00 -0.1500082858934205787271E+00  0.2504181476638525083445E+00 -0.2058533822122762119156E-01  0.9997027456190183958284E+00 -0.1306385288166418169598E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           244                             0                             0                             0                             0                             0                             0
 -0.3118738012146169413796E+00 -0.1500082858934205787271E+00  0.2092955535713510450968E+00 -0.1878568175634343431768E-01  0.9997027456190183958284E+00 -0.1554086750298984929974E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           245                             0                             0                             0                             0                             0                             0
 -0.2770780515949796130037E+00 -0.1500082858934205787271E+00  0.1722418437234147226000E+00 -0.1668976386813936577114E-01  0.9997027456190185068508E+00 -0.1777279336012913338316E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           246                             0                             0                             0                             0                             0                             0
 -0.2379126155832843592108E+00 -0.1500082858934205787271E+00  0.1398413772591591275329E+00 -0.1433063843375306616046E-01  0.9997027456190183958284E+00 -0.1972443164902704798580E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           247                             0                             0                             0                             0                             0                             0
 -0.1949951555017334081654E+00 -0.1500082858934205787271E+00  0.1126051288898262114913E+00 -0.1174551027055805232924E-01  0.9997027456190182848061E+00 -0.2136500386801546205739E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           248                             0                             0                             0                             0                             0                             0
 -0.1490025053334597948673E+00 -0.1500082858934205787271E+00  0.9096263052234598855961E-01 -0.8975148393968564869416E-02  0.9997027456190183958284E+00 -0.2266863721317062194127E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           249                             0                             0                             0                             0                             0                             0
 -0.1006599966462959627744E+00 -0.1500082858934205787271E+00  0.7525519728457608081840E-01 -0.6063243065712461792038E-02  0.9997027456190183958284E+00 -0.2361477260788657356327E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           250                             0                             0                             0                             0                             0                             0
 -0.5073001968065237593519E-01 -0.1500082858934205787271E+00  0.6573054478184148230469E-01 -0.3055716772304211455852E-02  0.9997027456190183958284E+00 -0.2418848893179479167537E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           251                             0                             0                             0                             0                             0                             0
  0.2618816711648417169247E-16 -0.1437667757714674865444E+00  0.3961477459921680654986E-01 -0.2806759479253668874850E-16  0.8887570259382635562417E+00  0.4583786086254166280973E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           252                             0                             0                             0                             0                             0                             0
  0.5360317224715847178595E-01 -0.1437667757714674865444E+00  0.4298720034488684449414E-01 -0.5745007321573015329763E-01  0.8887570259382635562417E+00  0.4547641563853511703641E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           253                             0                             0                             0                             0                             0                             0
  0.1063609904469962341711E+00 -0.1437667757714674865444E+00  0.5305129241329831213392E-01 -0.1139941244578379780927E+00  0.8887570259382634452194E+00  0.4439778017361496464943E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           254                             0                             0                             0                             0                             0                             0
  0.1574414322905090257709E+00 -0.1437667757714674865444E+00  0.6964833406053511088984E-01 -0.1687404202604566305634E+00  0.8887570259382635562417E+00  0.4261896519340859779135E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           255                             0                             0                             0                             0                             0                             0
  0.2060389286958475563161E+00 -0.1437667757714674865444E+00  0.9251658002522822332736E-01 -0.2208255788349266779402E+00  0.8887570259382636672640E+00  0.4016802367276643415117E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           256                             0                             0                             0                             0                             0                             0
  0.2513870681139626084288E+00 -0.1437667757714674865444E+00  0.1212953844076864462487E+00 -0.2694281861163633218226E+00  0.8887570259382635562417E+00  0.3708360842359049169836E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           257                             0                             0                             0                             0                             0                             0
  0.2927706832965649708100E+00 -0.1437667757714674865444E+00  0.1555308882711740614546E+00 -0.3137817499541479815406E+00  0.8887570259382635562417E+00  0.3341436251690063641284E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           258                             0                             0                             0                             0                             0                             0
  0.3295371299108518226006E+00 -0.1437667757714674865444E+00  0.1946831772684651795657E+00 -0.3531867881510241113929E+00  0.8887570259382635562417E+00  0.2921815215254661701749E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           259                             0                             0                             0                             0                             0                             0
  0.3611065791305050343141E+00 -0.1437667757714674865444E+00  0.2381347964136286132764E+00 -0.3870218597151981465565E+00  0.8887570259382635562417E+00  0.2456115407466888111987E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           260                             0                             0                             0                             0                             0                             0
  0.3869811618826558552442E+00 -0.1437667757714674865444E+00  0.2852004877160061457886E+00 -0.4147533653560109279113E+00  0.8887570259382635562417E+00  0.1951681192491135641287E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           261                             0                             0                             0                             0                             0                             0
  0.4067528205405763763736E+00 -0.1437667757714674865444E+00  0.3351379971080780673098E+00 -0.4359439626635083775419E+00  0.8887570259382634452194E+00  0.1416467799231965751794E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           262                             0                             0                             0                             0                             0                             0
  0.4201097442362148881578E+00 -0.1437667757714674865444E+00  0.3871597802355092876603E+00 -0.4502594632595021129085E+00  0.8887570259382636672640E+00  0.8589158626220595726952E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           263                             0                             0                             0                             0                             0                             0
  0.4268412863038515414615E+00 -0.1437667757714674865444E+00  0.4404454225020733026952E+00 -0.4574741031479276354155E+00  0.8887570259382635562417E+00  0.2878183097671375284543E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           264                             0                             0                             0                             0                             0                             0
  0.4268412863038515414615E+00 -0.1437667757714674865444E+00  0.4941545774979266836269E+00 -0.4574741031479276354155E+00  0.8887570259382635562417E+00 -0.2878183097671375284543E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           265                             0                             0                             0                             0                             0                             0
  0.4201097442362148881578E+00 -0.1437667757714674865444E+00  0.5474402197644907541729E+00 -0.4502594632595021129085E+00  0.8887570259382636672640E+00 -0.8589158626220595726952E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           266                             0                             0                             0                             0                             0                             0
  0.4067528205405764318847E+00 -0.1437667757714674865444E+00  0.5994620028919218635011E+00 -0.4359439626635083775419E+00  0.8887570259382635562417E+00 -0.1416467799231964919127E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           267                             0                             0                             0                             0                             0                             0
  0.3869811618826557997330E+00 -0.1437667757714674865444E+00  0.6493995122839939515558E+00 -0.4147533653560108724001E+00  0.8887570259382635562417E+00 -0.1951681192491136473954E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           268                             0                             0                             0                             0                             0                             0
  0.3611065791305049232918E+00 -0.1437667757714674865444E+00  0.6964652035863715395791E+00 -0.3870218597151979800230E+00  0.8887570259382635562417E+00 -0.2456115407466889777321E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           269                             0                             0                             0                             0                             0                             0
  0.3295371299108517670895E+00 -0.1437667757714674865444E+00  0.7399168227315349177786E+00 -0.3531867881510240558818E+00  0.8887570259382634452194E+00 -0.2921815215254662256861E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           270                             0                             0                             0                             0                             0                             0
  0.2927706832965650818323E+00 -0.1437667757714674865444E+00  0.7790691117288257583340E+00 -0.3137817499541480925629E+00  0.8887570259382635562417E+00 -0.3341436251690062531061E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           271                             0                             0                             0                             0                             0                             0
  0.2513870681139626084288E+00 -0.1437667757714674865444E+00  0.8133046155923135955845E+00 -0.2694281861163633218226E+00  0.8887570259382635562417E+00 -0.3708360842359049169836E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           272                             0                             0                             0                             0                             0                             0
  0.2060389286958475008049E+00 -0.1437667757714674865444E+00  0.8420834199747717629947E+00 -0.2208255788349265946735E+00  0.8887570259382635562417E+00 -0.4016802367276643970229E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           273                             0                             0                             0                             0                             0                             0
  0.1574414322905090257709E+00 -0.1437667757714674865444E+00  0.8649516659394649309434E+00 -0.1687404202604566305634E+00  0.8887570259382635562417E+00 -0.4261896519340859779135E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           274                             0                             0                             0                             0                             0                             0
  0.1063609904469964284601E+00 -0.1437667757714674865444E+00  0.8815487075867016741881E+00 -0.1139941244578381723818E+00  0.8887570259382635562417E+00 -0.4439778017361495909832E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           275                             0                             0                             0                             0                             0                             0
  0.5360317224715856893047E-01 -0.1437667757714674865444E+00  0.8916127996551130863168E+00 -0.5745007321573025738104E-01  0.8887570259382634452194E+00 -0.4547641563853511148530E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           276                             0                             0                             0                             0                             0                             0
  0.2618816711648417169247E-16 -0.1437667757714674865444E+00  0.8949852254007831797722E+00 -0.2806759479253668874850E-16  0.8887570259382635562417E+00 -0.4583786086254166280973E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           277                             0                             0                             0                             0                             0                             0
 -0.5360317224715852035821E-01 -0.1437667757714674865444E+00  0.8916127996551130863168E+00  0.5745007321573020186989E-01  0.8887570259382633341971E+00 -0.4547641563853511148530E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           278                             0                             0                             0                             0                             0                             0
 -0.1063609904469961925377E+00 -0.1437667757714674865444E+00  0.8815487075867016741881E+00  0.1139941244578379225816E+00  0.8887570259382636672640E+00 -0.4439778017361497020055E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           279                             0                             0                             0                             0                             0                             0
 -0.1574414322905089980154E+00 -0.1437667757714674865444E+00  0.8649516659394649309434E+00  0.1687404202604565750523E+00  0.8887570259382635562417E+00 -0.4261896519340859779135E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           280                             0                             0                             0                             0                             0                             0
 -0.2060389286958476118272E+00 -0.1437667757714674865444E+00  0.8420834199747717629947E+00  0.2208255788349267334514E+00  0.8887570259382635562417E+00 -0.4016802367276642860006E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           281                             0                             0                             0                             0                             0                             0
 -0.2513870681139623863842E+00 -0.1437667757714674865444E+00  0.8133046155923137066068E+00  0.2694281861163630997780E+00  0.8887570259382635562417E+00 -0.3708360842359050835171E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           282                             0                             0                             0                             0                             0                             0
 -0.2927706832965649152989E+00 -0.1437667757714674865444E+00  0.7790691117288259803786E+00  0.3137817499541478705183E+00  0.8887570259382635562417E+00 -0.3341436251690064751507E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           283                             0                             0                             0                             0                             0                             0
 -0.3295371299108518781118E+00 -0.1437667757714674865444E+00  0.7399168227315348067563E+00  0.3531867881510241669041E+00  0.8887570259382635562417E+00 -0.2921815215254661146638E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           284                             0                             0                             0                             0                             0                             0
 -0.3611065791305050898252E+00 -0.1437667757714674865444E+00  0.6964652035863712065122E+00  0.3870218597151982020677E+00  0.8887570259382634452194E+00 -0.2456115407466886724208E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           285                             0                             0                             0                             0                             0                             0
 -0.3869811618826559662665E+00 -0.1437667757714674865444E+00  0.6493995122839936184889E+00  0.4147533653560109834224E+00  0.8887570259382635562417E+00 -0.1951681192491133420841E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           286                             0                             0                             0                             0                             0                             0
 -0.4067528205405763763736E+00 -0.1437667757714674865444E+00  0.5994620028919219745234E+00  0.4359439626635083775419E+00  0.8887570259382635562417E+00 -0.1416467799231966306905E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           287                             0                             0                             0                             0                             0                             0
 -0.4201097442362148881578E+00 -0.1437667757714674865444E+00  0.5474402197644906431506E+00  0.4502594632595021129085E+00  0.8887570259382635562417E+00 -0.8589158626220591563616E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           288                             0                             0                             0                             0                             0                             0
 -0.4268412863038515414615E+00 -0.1437667757714674865444E+00  0.4941545774979265726046E+00  0.4574741031479276354155E+00  0.8887570259382635562417E+00 -0.2878183097671360712866E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           289                             0                             0                             0                             0                             0                             0
 -0.4268412863038515414615E+00 -0.1437667757714674865444E+00  0.4404454225020735247398E+00  0.4574741031479276354155E+00  0.8887570259382635562417E+00  0.2878183097671349957580E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           290                             0                             0                             0                             0                             0                             0
 -0.4201097442362148881578E+00 -0.1437667757714674865444E+00  0.3871597802355094541937E+00  0.4502594632595021129085E+00  0.8887570259382635562417E+00  0.8589158626220580461386E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           291                             0                             0                             0                             0                             0                             0
 -0.4067528205405764318847E+00 -0.1437667757714674865444E+00  0.3351379971080781228210E+00  0.4359439626635083775419E+00  0.8887570259382636672640E+00  0.1416467799231965196682E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           292                             0                             0                             0                             0                             0                             0
 -0.3869811618826560217776E+00 -0.1437667757714674865444E+00  0.2852004877160064788555E+00  0.4147533653560110389336E+00  0.8887570259382635562417E+00  0.1951681192491132310618E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           293                             0                             0                             0                             0                             0                             0
 -0.3611065791305049232918E+00 -0.1437667757714674865444E+00  0.2381347964136285300096E+00  0.3870218597151980355342E+00  0.8887570259382635562417E+00  0.2456115407466889222210E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           294                             0                             0                             0                             0                             0                             0
 -0.3295371299108519336230E+00 -0.1437667757714674865444E+00  0.1946831772684652905880E+00  0.3531867881510242779264E+00  0.8887570259382635562417E+00  0.2921815215254660591526E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           295                             0                             0                             0                             0                             0                             0
 -0.2927706832965651373435E+00 -0.1437667757714674865444E+00  0.1555308882711741724769E+00  0.3137817499541481480740E+00  0.8887570259382636672640E+00  0.3341436251690062531061E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           296                             0                             0                             0                             0                             0                             0
 -0.2513870681139626084288E+00 -0.1437667757714674865444E+00  0.1212953844076865017598E+00  0.2694281861163633773337E+00  0.8887570259382635562417E+00  0.3708360842359048614725E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           297                             0                             0                             0                             0                             0                             0
 -0.2060389286958478616274E+00 -0.1437667757714674865444E+00  0.9251658002522838986081E-01  0.2208255788349270110071E+00  0.8887570259382634452194E+00  0.4016802367276641194671E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           298                             0                             0                             0                             0                             0                             0
 -0.1574414322905089147486E+00 -0.1437667757714674865444E+00  0.6964833406053505537869E-01  0.1687404202604564917856E+00  0.8887570259382635562417E+00  0.4261896519340860334246E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           299                             0                             0                             0                             0                             0                             0
 -0.1063609904469964700935E+00 -0.1437667757714674865444E+00  0.5305129241329836764507E-01  0.1139941244578382278929E+00  0.8887570259382635562417E+00  0.4439778017361495909832E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           300                             0                             0                             0                             0                             0                             0
 -0.5360317224715861056383E-01 -0.1437667757714674865444E+00  0.4298720034488690000529E-01  0.5745007321573030595330E-01  0.8887570259382634452194E+00  0.4547641563853511148530E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           301                             0                             0                             0                             0                             0                             0
  0.2745650093261849334703E-16 -0.1252491859380352179354E+00  0.1890131146817547458383E-01 -0.4615100205551978034002E-16  0.6572151062641362617711E+00  0.7537030609585050333621E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           302                             0                             0                             0                             0                             0                             0
  0.5619925755968688263486E-01 -0.1252491859380352179354E+00  0.2243706905744530244462E-01 -0.9446404177724336548305E-01  0.6572151062641362617711E+00  0.7477598872026549603476E+00
