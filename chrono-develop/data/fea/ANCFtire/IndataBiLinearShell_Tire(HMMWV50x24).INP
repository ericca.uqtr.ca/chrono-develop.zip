                           735                             1                             3                           735                           736                           785                           786
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           736                             1                             3                           736                           737                           786                           787
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           737                             1                             3                           737                           738                           787                           788
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           738                             1                             3                           738                           739                           788                           789
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           739                             1                             3                           739                           740                           789                           790
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           740                             1                             3                           740                           741                           790                           791
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           741                             1                             3                           741                           742                           791                           792
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           742                             1                             3                           742                           743                           792                           793
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           743                             1                             3                           743                           744                           793                           794
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           744                             1                             3                           744                           745                           794                           795
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           745                             1                             3                           745                           746                           795                           796
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           746                             1                             3                           746                           747                           796                           797
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           747                             1                             3                           747                           748                           797                           798
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           748                             1                             3                           748                           749                           798                           799
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           749                             1                             3                           749                           750                           799                           800
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           750                             1                             3                           750                           701                           800                           751
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           751                             1                             3                           751                           752                           801                           802
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           752                             1                             3                           752                           753                           802                           803
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           753                             1                             3                           753                           754                           803                           804
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           754                             1                             3                           754                           755                           804                           805
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           755                             1                             3                           755                           756                           805                           806
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           756                             1                             3                           756                           757                           806                           807
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           757                             1                             3                           757                           758                           807                           808
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           758                             1                             3                           758                           759                           808                           809
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           759                             1                             3                           759                           760                           809                           810
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           760                             1                             3                           760                           761                           810                           811
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           761                             1                             3                           761                           762                           811                           812
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           762                             1                             3                           762                           763                           812                           813
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           763                             1                             3                           763                           764                           813                           814
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           764                             1                             3                           764                           765                           814                           815
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           765                             1                             3                           765                           766                           815                           816
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           766                             1                             3                           766                           767                           816                           817
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           767                             1                             3                           767                           768                           817                           818
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           768                             1                             3                           768                           769                           818                           819
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           769                             1                             3                           769                           770                           819                           820
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           770                             1                             3                           770                           771                           820                           821
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           771                             1                             3                           771                           772                           821                           822
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           772                             1                             3                           772                           773                           822                           823
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           773                             1                             3                           773                           774                           823                           824
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           774                             1                             3                           774                           775                           824                           825
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           775                             1                             3                           775                           776                           825                           826
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           776                             1                             3                           776                           777                           826                           827
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           777                             1                             3                           777                           778                           827                           828
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           778                             1                             3                           778                           779                           828                           829
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           779                             1                             3                           779                           780                           829                           830
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           780                             1                             3                           780                           781                           830                           831
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           781                             1                             3                           781                           782                           831                           832
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           782                             1                             3                           782                           783                           832                           833
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           783                             1                             3                           783                           784                           833                           834
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           784                             1                             3                           784                           785                           834                           835
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           785                             1                             3                           785                           786                           835                           836
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           786                             1                             3                           786                           787                           836                           837
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           787                             1                             3                           787                           788                           837                           838
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           788                             1                             3                           788                           789                           838                           839
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           789                             1                             3                           789                           790                           839                           840
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           790                             1                             3                           790                           791                           840                           841
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           791                             1                             3                           791                           792                           841                           842
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           792                             1                             3                           792                           793                           842                           843
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           793                             1                             3                           793                           794                           843                           844
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           794                             1                             3                           794                           795                           844                           845
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           795                             1                             3                           795                           796                           845                           846
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           796                             1                             3                           796                           797                           846                           847
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           797                             1                             3                           797                           798                           847                           848
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           798                             1                             3                           798                           799                           848                           849
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           799                             1                             3                           799                           800                           849                           850
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           800                             1                             3                           800                           751                           850                           801
  0.5862223775305532014190E-01  0.2087836460363719573441E-01
                           801                             1                             3                           801                           802                           851                           852
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           802                             1                             3                           802                           803                           852                           853
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           803                             1                             3                           803                           804                           853                           854
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           804                             1                             3                           804                           805                           854                           855
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           805                             1                             3                           805                           806                           855                           856
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           806                             1                             3                           806                           807                           856                           857
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           807                             1                             3                           807                           808                           857                           858
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           808                             1                             3                           808                           809                           858                           859
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           809                             1                             3                           809                           810                           859                           860
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           810                             1                             3                           810                           811                           860                           861
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           811                             1                             3                           811                           812                           861                           862
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           812                             1                             3                           812                           813                           862                           863
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           813                             1                             3                           813                           814                           863                           864
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           814                             1                             3                           814                           815                           864                           865
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           815                             1                             3                           815                           816                           865                           866
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           816                             1                             3                           816                           817                           866                           867
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           817                             1                             3                           817                           818                           867                           868
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           818                             1                             3                           818                           819                           868                           869
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           819                             1                             3                           819                           820                           869                           870
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           820                             1                             3                           820                           821                           870                           871
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           821                             1                             3                           821                           822                           871                           872
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           822                             1                             3                           822                           823                           872                           873
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           823                             1                             3                           823                           824                           873                           874
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           824                             1                             3                           824                           825                           874                           875
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           825                             1                             3                           825                           826                           875                           876
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           826                             1                             3                           826                           827                           876                           877
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           827                             1                             3                           827                           828                           877                           878
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           828                             1                             3                           828                           829                           878                           879
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           829                             1                             3                           829                           830                           879                           880
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           830                             1                             3                           830                           831                           880                           881
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           831                             1                             3                           831                           832                           881                           882
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           832                             1                             3                           832                           833                           882                           883
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           833                             1                             3                           833                           834                           883                           884
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           834                             1                             3                           834                           835                           884                           885
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           835                             1                             3                           835                           836                           885                           886
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           836                             1                             3                           836                           837                           886                           887
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           837                             1                             3                           837                           838                           887                           888
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           838                             1                             3                           838                           839                           888                           889
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           839                             1                             3                           839                           840                           889                           890
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           840                             1                             3                           840                           841                           890                           891
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           841                             1                             3                           841                           842                           891                           892
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           842                             1                             3                           842                           843                           892                           893
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           843                             1                             3                           843                           844                           893                           894
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           844                             1                             3                           844                           845                           894                           895
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           845                             1                             3                           845                           846                           895                           896
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           846                             1                             3                           846                           847                           896                           897
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           847                             1                             3                           847                           848                           897                           898
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           848                             1                             3                           848                           849                           898                           899
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           849                             1                             3                           849                           850                           899                           900
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           850                             1                             3                           850                           801                           900                           851
  0.5834058645912798546362E-01  0.2130598452915483109749E-01
                           851                             1                             3                           851                           852                           901                           902
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           852                             1                             3                           852                           853                           902                           903
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           853                             1                             3                           853                           854                           903                           904
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           854                             1                             3                           854                           855                           904                           905
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           855                             1                             3                           855                           856                           905                           906
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           856                             1                             3                           856                           857                           906                           907
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           857                             1                             3                           857                           858                           907                           908
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           858                             1                             3                           858                           859                           908                           909
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           859                             1                             3                           859                           860                           909                           910
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           860                             1                             3                           860                           861                           910                           911
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           861                             1                             3                           861                           862                           911                           912
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           862                             1                             3                           862                           863                           912                           913
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           863                             1                             3                           863                           864                           913                           914
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           864                             1                             3                           864                           865                           914                           915
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           865                             1                             3                           865                           866                           915                           916
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           866                             1                             3                           866                           867                           916                           917
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           867                             1                             3                           867                           868                           917                           918
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           868                             1                             3                           868                           869                           918                           919
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           869                             1                             3                           869                           870                           919                           920
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           870                             1                             3                           870                           871                           920                           921
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           871                             1                             3                           871                           872                           921                           922
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           872                             1                             3                           872                           873                           922                           923
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           873                             1                             3                           873                           874                           923                           924
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           874                             1                             3                           874                           875                           924                           925
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           875                             1                             3                           875                           876                           925                           926
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           876                             1                             3                           876                           877                           926                           927
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           877                             1                             3                           877                           878                           927                           928
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           878                             1                             3                           878                           879                           928                           929
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           879                             1                             3                           879                           880                           929                           930
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           880                             1                             3                           880                           881                           930                           931
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           881                             1                             3                           881                           882                           931                           932
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           882                             1                             3                           882                           883                           932                           933
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           883                             1                             3                           883                           884                           933                           934
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           884                             1                             3                           884                           885                           934                           935
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           885                             1                             3                           885                           886                           935                           936
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           886                             1                             3                           886                           887                           936                           937
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           887                             1                             3                           887                           888                           937                           938
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           888                             1                             3                           888                           889                           938                           939
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           889                             1                             3                           889                           890                           939                           940
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           890                             1                             3                           890                           891                           940                           941
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           891                             1                             3                           891                           892                           941                           942
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           892                             1                             3                           892                           893                           942                           943
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           893                             1                             3                           893                           894                           943                           944
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           894                             1                             3                           894                           895                           944                           945
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           895                             1                             3                           895                           896                           945                           946
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           896                             1                             3                           896                           897                           946                           947
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           897                             1                             3                           897                           898                           947                           948
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           898                             1                             3                           898                           899                           948                           949
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           899                             1                             3                           899                           900                           949                           950
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           900                             1                             3                           900                           851                           950                           901
  0.5721044933346199068414E-01  0.2497836844596560551546E-01
                           901                             1                             2                           901                           902                           951                           952
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           902                             1                             2                           902                           903                           952                           953
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           903                             1                             2                           903                           904                           953                           954
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           904                             1                             2                           904                           905                           954                           955
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           905                             1                             2                           905                           906                           955                           956
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           906                             1                             2                           906                           907                           956                           957
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           907                             1                             2                           907                           908                           957                           958
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           908                             1                             2                           908                           909                           958                           959
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           909                             1                             2                           909                           910                           959                           960
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           910                             1                             2                           910                           911                           960                           961
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           911                             1                             2                           911                           912                           961                           962
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           912                             1                             2                           912                           913                           962                           963
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           913                             1                             2                           913                           914                           963                           964
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           914                             1                             2                           914                           915                           964                           965
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           915                             1                             2                           915                           916                           965                           966
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           916                             1                             2                           916                           917                           966                           967
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           917                             1                             2                           917                           918                           967                           968
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           918                             1                             2                           918                           919                           968                           969
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           919                             1                             2                           919                           920                           969                           970
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           920                             1                             2                           920                           921                           970                           971
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           921                             1                             2                           921                           922                           971                           972
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           922                             1                             2                           922                           923                           972                           973
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           923                             1                             2                           923                           924                           973                           974
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           924                             1                             2                           924                           925                           974                           975
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           925                             1                             2                           925                           926                           975                           976
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           926                             1                             2                           926                           927                           976                           977
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           927                             1                             2                           927                           928                           977                           978
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           928                             1                             2                           928                           929                           978                           979
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           929                             1                             2                           929                           930                           979                           980
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           930                             1                             2                           930                           931                           980                           981
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           931                             1                             2                           931                           932                           981                           982
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           932                             1                             2                           932                           933                           982                           983
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           933                             1                             2                           933                           934                           983                           984
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           934                             1                             2                           934                           935                           984                           985
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           935                             1                             2                           935                           936                           985                           986
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           936                             1                             2                           936                           937                           986                           987
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           937                             1                             2                           937                           938                           987                           988
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           938                             1                             2                           938                           939                           988                           989
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           939                             1                             2                           939                           940                           989                           990
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           940                             1                             2                           940                           941                           990                           991
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           941                             1                             2                           941                           942                           991                           992
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           942                             1                             2                           942                           943                           992                           993
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           943                             1                             2                           943                           944                           993                           994
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           944                             1                             2                           944                           945                           994                           995
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           945                             1                             2                           945                           946                           995                           996
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           946                             1                             2                           946                           947                           996                           997
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           947                             1                             2                           947                           948                           997                           998
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           948                             1                             2                           948                           949                           998                           999
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           949                             1                             2                           949                           950                           999                          1000
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           950                             1                             2                           950                           901                          1000                           951
  0.5504597575877441528736E-01  0.2778396458610110988929E-01
                           951                             1                             2                           951                           952                          1001                          1002
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           952                             1                             2                           952                           953                          1002                          1003
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           953                             1                             2                           953                           954                          1003                          1004
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           954                             1                             2                           954                           955                          1004                          1005
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           955                             1                             2                           955                           956                          1005                          1006
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           956                             1                             2                           956                           957                          1006                          1007
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           957                             1                             2                           957                           958                          1007                          1008
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           958                             1                             2                           958                           959                          1008                          1009
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           959                             1                             2                           959                           960                          1009                          1010
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           960                             1                             2                           960                           961                          1010                          1011
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           961                             1                             2                           961                           962                          1011                          1012
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           962                             1                             2                           962                           963                          1012                          1013
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           963                             1                             2                           963                           964                          1013                          1014
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           964                             1                             2                           964                           965                          1014                          1015
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           965                             1                             2                           965                           966                          1015                          1016
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           966                             1                             2                           966                           967                          1016                          1017
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           967                             1                             2                           967                           968                          1017                          1018
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           968                             1                             2                           968                           969                          1018                          1019
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           969                             1                             2                           969                           970                          1019                          1020
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           970                             1                             2                           970                           971                          1020                          1021
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           971                             1                             2                           971                           972                          1021                          1022
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           972                             1                             2                           972                           973                          1022                          1023
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           973                             1                             2                           973                           974                          1023                          1024
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           974                             1                             2                           974                           975                          1024                          1025
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           975                             1                             2                           975                           976                          1025                          1026
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           976                             1                             2                           976                           977                          1026                          1027
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           977                             1                             2                           977                           978                          1027                          1028
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           978                             1                             2                           978                           979                          1028                          1029
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           979                             1                             2                           979                           980                          1029                          1030
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           980                             1                             2                           980                           981                          1030                          1031
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           981                             1                             2                           981                           982                          1031                          1032
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           982                             1                             2                           982                           983                          1032                          1033
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           983                             1                             2                           983                           984                          1033                          1034
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           984                             1                             2                           984                           985                          1034                          1035
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           985                             1                             2                           985                           986                          1035                          1036
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           986                             1                             2                           986                           987                          1036                          1037
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           987                             1                             2                           987                           988                          1037                          1038
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           988                             1                             2                           988                           989                          1038                          1039
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           989                             1                             2                           989                           990                          1039                          1040
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           990                             1                             2                           990                           991                          1040                          1041
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           991                             1                             2                           991                           992                          1041                          1042
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           992                             1                             2                           992                           993                          1042                          1043
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           993                             1                             2                           993                           994                          1043                          1044
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           994                             1                             2                           994                           995                          1044                          1045
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           995                             1                             2                           995                           996                          1045                          1046
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           996                             1                             2                           996                           997                          1046                          1047
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           997                             1                             2                           997                           998                          1047                          1048
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           998                             1                             2                           998                           999                          1048                          1049
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                           999                             1                             2                           999                          1000                          1049                          1050
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                          1000                             1                             2                          1000                           951                          1050                          1001
  0.5230414630906707329494E-01  0.2375860202875963028690E-01
                          1001                             1                             2                          1001                          1002                          1051                          1052
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1002                             1                             2                          1002                          1003                          1052                          1053
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1003                             1                             2                          1003                          1004                          1053                          1054
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1004                             1                             2                          1004                          1005                          1054                          1055
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1005                             1                             2                          1005                          1006                          1055                          1056
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1006                             1                             2                          1006                          1007                          1056                          1057
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1007                             1                             2                          1007                          1008                          1057                          1058
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1008                             1                             2                          1008                          1009                          1058                          1059
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1009                             1                             2                          1009                          1010                          1059                          1060
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1010                             1                             2                          1010                          1011                          1060                          1061
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1011                             1                             2                          1011                          1012                          1061                          1062
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1012                             1                             2                          1012                          1013                          1062                          1063
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1013                             1                             2                          1013                          1014                          1063                          1064
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1014                             1                             2                          1014                          1015                          1064                          1065
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1015                             1                             2                          1015                          1016                          1065                          1066
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1016                             1                             2                          1016                          1017                          1066                          1067
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1017                             1                             2                          1017                          1018                          1067                          1068
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1018                             1                             2                          1018                          1019                          1068                          1069
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1019                             1                             2                          1019                          1020                          1069                          1070
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1020                             1                             2                          1020                          1021                          1070                          1071
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1021                             1                             2                          1021                          1022                          1071                          1072
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1022                             1                             2                          1022                          1023                          1072                          1073
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1023                             1                             2                          1023                          1024                          1073                          1074
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1024                             1                             2                          1024                          1025                          1074                          1075
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1025                             1                             2                          1025                          1026                          1075                          1076
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1026                             1                             2                          1026                          1027                          1076                          1077
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1027                             1                             2                          1027                          1028                          1077                          1078
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1028                             1                             2                          1028                          1029                          1078                          1079
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1029                             1                             2                          1029                          1030                          1079                          1080
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1030                             1                             2                          1030                          1031                          1080                          1081
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1031                             1                             2                          1031                          1032                          1081                          1082
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1032                             1                             2                          1032                          1033                          1082                          1083
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1033                             1                             2                          1033                          1034                          1083                          1084
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1034                             1                             2                          1034                          1035                          1084                          1085
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1035                             1                             2                          1035                          1036                          1085                          1086
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1036                             1                             2                          1036                          1037                          1086                          1087
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1037                             1                             2                          1037                          1038                          1087                          1088
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1038                             1                             2                          1038                          1039                          1088                          1089
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1039                             1                             2                          1039                          1040                          1089                          1090
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1040                             1                             2                          1040                          1041                          1090                          1091
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1041                             1                             2                          1041                          1042                          1091                          1092
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1042                             1                             2                          1042                          1043                          1092                          1093
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1043                             1                             2                          1043                          1044                          1093                          1094
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1044                             1                             2                          1044                          1045                          1094                          1095
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1045                             1                             2                          1045                          1046                          1095                          1096
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1046                             1                             2                          1046                          1047                          1096                          1097
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1047                             1                             2                          1047                          1048                          1097                          1098
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1048                             1                             2                          1048                          1049                          1098                          1099
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1049                             1                             2                          1049                          1050                          1099                          1100
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1050                             1                             2                          1050                          1001                          1100                          1051
  0.4870337345169745146833E-01  0.3467957746560013099213E-01
                          1051                             1                             2                          1051                          1052                          1101                          1102
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1052                             1                             2                          1052                          1053                          1102                          1103
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1053                             1                             2                          1053                          1054                          1103                          1104
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1054                             1                             2                          1054                          1055                          1104                          1105
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1055                             1                             2                          1055                          1056                          1105                          1106
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1056                             1                             2                          1056                          1057                          1106                          1107
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1057                             1                             2                          1057                          1058                          1107                          1108
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1058                             1                             2                          1058                          1059                          1108                          1109
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1059                             1                             2                          1059                          1060                          1109                          1110
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1060                             1                             2                          1060                          1061                          1110                          1111
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1061                             1                             2                          1061                          1062                          1111                          1112
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1062                             1                             2                          1062                          1063                          1112                          1113
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1063                             1                             2                          1063                          1064                          1113                          1114
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1064                             1                             2                          1064                          1065                          1114                          1115
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1065                             1                             2                          1065                          1066                          1115                          1116
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1066                             1                             2                          1066                          1067                          1116                          1117
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1067                             1                             2                          1067                          1068                          1117                          1118
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1068                             1                             2                          1068                          1069                          1118                          1119
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1069                             1                             2                          1069                          1070                          1119                          1120
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1070                             1                             2                          1070                          1071                          1120                          1121
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1071                             1                             2                          1071                          1072                          1121                          1122
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1072                             1                             2                          1072                          1073                          1122                          1123
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1073                             1                             2                          1073                          1074                          1123                          1124
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1074                             1                             2                          1074                          1075                          1124                          1125
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1075                             1                             2                          1075                          1076                          1125                          1126
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1076                             1                             2                          1076                          1077                          1126                          1127
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1077                             1                             2                          1077                          1078                          1127                          1128
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1078                             1                             2                          1078                          1079                          1128                          1129
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1079                             1                             2                          1079                          1080                          1129                          1130
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1080                             1                             2                          1080                          1081                          1130                          1131
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1081                             1                             2                          1081                          1082                          1131                          1132
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1082                             1                             2                          1082                          1083                          1132                          1133
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1083                             1                             2                          1083                          1084                          1133                          1134
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1084                             1                             2                          1084                          1085                          1134                          1135
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1085                             1                             2                          1085                          1086                          1135                          1136
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1086                             1                             2                          1086                          1087                          1136                          1137
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1087                             1                             2                          1087                          1088                          1137                          1138
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1088                             1                             2                          1088                          1089                          1138                          1139
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1089                             1                             2                          1089                          1090                          1139                          1140
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1090                             1                             2                          1090                          1091                          1140                          1141
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1091                             1                             2                          1091                          1092                          1141                          1142
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1092                             1                             2                          1092                          1093                          1142                          1143
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1093                             1                             2                          1093                          1094                          1143                          1144
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1094                             1                             2                          1094                          1095                          1144                          1145
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1095                             1                             2                          1095                          1096                          1145                          1146
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1096                             1                             2                          1096                          1097                          1146                          1147
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1097                             1                             2                          1097                          1098                          1147                          1148
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1098                             1                             2                          1098                          1099                          1148                          1149
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1099                             1                             2                          1099                          1100                          1149                          1150
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1100                             1                             2                          1100                          1051                          1150                          1101
  0.4440532969413377162304E-01  0.3547265021575876642324E-01
                          1101                             1                             1                          1101                          1102                          1151                          1152
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
