 NumFlexBodys
              1
 SYSPR [NumElems, NumElemsX, NumElemsY, Node]
           1200             50             24           1250
 ELEMN [#ofElem, ETYPE, LayID, IC / EL(m), EW(m)]
                             1                             1                             1                             1                             2                            51                            52
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                             2                             1                             1                             2                             3                            52                            53
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                             3                             1                             1                             3                             4                            53                            54
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                             4                             1                             1                             4                             5                            54                            55
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                             5                             1                             1                             5                             6                            55                            56
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                             6                             1                             1                             6                             7                            56                            57
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                             7                             1                             1                             7                             8                            57                            58
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                             8                             1                             1                             8                             9                            58                            59
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                             9                             1                             1                             9                            10                            59                            60
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            10                             1                             1                            10                            11                            60                            61
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            11                             1                             1                            11                            12                            61                            62
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            12                             1                             1                            12                            13                            62                            63
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            13                             1                             1                            13                            14                            63                            64
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            14                             1                             1                            14                            15                            64                            65
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            15                             1                             1                            15                            16                            65                            66
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            16                             1                             1                            16                            17                            66                            67
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            17                             1                             1                            17                            18                            67                            68
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            18                             1                             1                            18                            19                            68                            69
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            19                             1                             1                            19                            20                            69                            70
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            20                             1                             1                            20                            21                            70                            71
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            21                             1                             1                            21                            22                            71                            72
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            22                             1                             1                            22                            23                            72                            73
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            23                             1                             1                            23                            24                            73                            74
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            24                             1                             1                            24                            25                            74                            75
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            25                             1                             1                            25                            26                            75                            76
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            26                             1                             1                            26                            27                            76                            77
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            27                             1                             1                            27                            28                            77                            78
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            28                             1                             1                            28                            29                            78                            79
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            29                             1                             1                            29                            30                            79                            80
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            30                             1                             1                            30                            31                            80                            81
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            31                             1                             1                            31                            32                            81                            82
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            32                             1                             1                            32                            33                            82                            83
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            33                             1                             1                            33                            34                            83                            84
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            34                             1                             1                            34                            35                            84                            85
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            35                             1                             1                            35                            36                            85                            86
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            36                             1                             1                            36                            37                            86                            87
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            37                             1                             1                            37                            38                            87                            88
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            38                             1                             1                            38                            39                            88                            89
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            39                             1                             1                            39                            40                            89                            90
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            40                             1                             1                            40                            41                            90                            91
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            41                             1                             1                            41                            42                            91                            92
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            42                             1                             1                            42                            43                            92                            93
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            43                             1                             1                            43                            44                            93                            94
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            44                             1                             1                            44                            45                            94                            95
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            45                             1                             1                            45                            46                            95                            96
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            46                             1                             1                            46                            47                            96                            97
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            47                             1                             1                            47                            48                            97                            98
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            48                             1                             1                            48                            49                            98                            99
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            49                             1                             1                            49                            50                            99                           100
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            50                             1                             1                            50                             1                           100                            51
  0.3585360042743576669544E-01  0.3488307704159736982730E-01
                            51                             1                             1                            51                            52                           101                           102
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            52                             1                             1                            52                            53                           102                           103
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            53                             1                             1                            53                            54                           103                           104
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            54                             1                             1                            54                            55                           104                           105
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            55                             1                             1                            55                            56                           105                           106
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            56                             1                             1                            56                            57                           106                           107
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            57                             1                             1                            57                            58                           107                           108
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            58                             1                             1                            58                            59                           108                           109
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            59                             1                             1                            59                            60                           109                           110
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            60                             1                             1                            60                            61                           110                           111
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            61                             1                             1                            61                            62                           111                           112
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            62                             1                             1                            62                            63                           112                           113
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            63                             1                             1                            63                            64                           113                           114
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            64                             1                             1                            64                            65                           114                           115
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            65                             1                             1                            65                            66                           115                           116
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            66                             1                             1                            66                            67                           116                           117
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            67                             1                             1                            67                            68                           117                           118
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            68                             1                             1                            68                            69                           118                           119
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            69                             1                             1                            69                            70                           119                           120
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            70                             1                             1                            70                            71                           120                           121
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            71                             1                             1                            71                            72                           121                           122
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            72                             1                             1                            72                            73                           122                           123
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            73                             1                             1                            73                            74                           123                           124
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            74                             1                             1                            74                            75                           124                           125
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            75                             1                             1                            75                            76                           125                           126
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            76                             1                             1                            76                            77                           126                           127
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            77                             1                             1                            77                            78                           127                           128
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            78                             1                             1                            78                            79                           128                           129
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            79                             1                             1                            79                            80                           129                           130
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            80                             1                             1                            80                            81                           130                           131
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            81                             1                             1                            81                            82                           131                           132
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            82                             1                             1                            82                            83                           132                           133
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            83                             1                             1                            83                            84                           133                           134
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            84                             1                             1                            84                            85                           134                           135
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            85                             1                             1                            85                            86                           135                           136
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            86                             1                             1                            86                            87                           136                           137
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            87                             1                             1                            87                            88                           137                           138
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            88                             1                             1                            88                            89                           138                           139
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            89                             1                             1                            89                            90                           139                           140
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            90                             1                             1                            90                            91                           140                           141
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            91                             1                             1                            91                            92                           141                           142
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            92                             1                             1                            92                            93                           142                           143
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            93                             1                             1                            93                            94                           143                           144
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            94                             1                             1                            94                            95                           144                           145
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            95                             1                             1                            95                            96                           145                           146
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            96                             1                             1                            96                            97                           146                           147
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            97                             1                             1                            97                            98                           147                           148
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            98                             1                             1                            98                            99                           148                           149
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                            99                             1                             1                            99                           100                           149                           150
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                           100                             1                             1                           100                            51                           150                           101
  0.4012966218941645124563E-01  0.3634531937081487279473E-01
                           101                             1                             2                           101                           102                           151                           152
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           102                             1                             2                           102                           103                           152                           153
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           103                             1                             2                           103                           104                           153                           154
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           104                             1                             2                           104                           105                           154                           155
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           105                             1                             2                           105                           106                           155                           156
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           106                             1                             2                           106                           107                           156                           157
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           107                             1                             2                           107                           108                           157                           158
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           108                             1                             2                           108                           109                           158                           159
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           109                             1                             2                           109                           110                           159                           160
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           110                             1                             2                           110                           111                           160                           161
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           111                             1                             2                           111                           112                           161                           162
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           112                             1                             2                           112                           113                           162                           163
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           113                             1                             2                           113                           114                           163                           164
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           114                             1                             2                           114                           115                           164                           165
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           115                             1                             2                           115                           116                           165                           166
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           116                             1                             2                           116                           117                           166                           167
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           117                             1                             2                           117                           118                           167                           168
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           118                             1                             2                           118                           119                           168                           169
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           119                             1                             2                           119                           120                           169                           170
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           120                             1                             2                           120                           121                           170                           171
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           121                             1                             2                           121                           122                           171                           172
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           122                             1                             2                           122                           123                           172                           173
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           123                             1                             2                           123                           124                           173                           174
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           124                             1                             2                           124                           125                           174                           175
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           125                             1                             2                           125                           126                           175                           176
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           126                             1                             2                           126                           127                           176                           177
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           127                             1                             2                           127                           128                           177                           178
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           128                             1                             2                           128                           129                           178                           179
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           129                             1                             2                           129                           130                           179                           180
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           130                             1                             2                           130                           131                           180                           181
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           131                             1                             2                           131                           132                           181                           182
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           132                             1                             2                           132                           133                           182                           183
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           133                             1                             2                           133                           134                           183                           184
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           134                             1                             2                           134                           135                           184                           185
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           135                             1                             2                           135                           136                           185                           186
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           136                             1                             2                           136                           137                           186                           187
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           137                             1                             2                           137                           138                           187                           188
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           138                             1                             2                           138                           139                           188                           189
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           139                             1                             2                           139                           140                           189                           190
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           140                             1                             2                           140                           141                           190                           191
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           141                             1                             2                           141                           142                           191                           192
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           142                             1                             2                           142                           143                           192                           193
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           143                             1                             2                           143                           144                           193                           194
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           144                             1                             2                           144                           145                           194                           195
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           145                             1                             2                           145                           146                           195                           196
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           146                             1                             2                           146                           147                           196                           197
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           147                             1                             2                           147                           148                           197                           198
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           148                             1                             2                           148                           149                           198                           199
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           149                             1                             2                           149                           150                           199                           200
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           150                             1                             2                           150                           101                           200                           151
  0.4440533033223330316996E-01  0.3547263962464578673783E-01
                           151                             1                             2                           151                           152                           201                           202
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           152                             1                             2                           152                           153                           202                           203
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           153                             1                             2                           153                           154                           203                           204
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           154                             1                             2                           154                           155                           204                           205
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           155                             1                             2                           155                           156                           205                           206
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           156                             1                             2                           156                           157                           206                           207
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           157                             1                             2                           157                           158                           207                           208
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           158                             1                             2                           158                           159                           208                           209
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           159                             1                             2                           159                           160                           209                           210
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           160                             1                             2                           160                           161                           210                           211
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           161                             1                             2                           161                           162                           211                           212
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           162                             1                             2                           162                           163                           212                           213
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           163                             1                             2                           163                           164                           213                           214
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           164                             1                             2                           164                           165                           214                           215
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           165                             1                             2                           165                           166                           215                           216
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           166                             1                             2                           166                           167                           216                           217
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           167                             1                             2                           167                           168                           217                           218
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           168                             1                             2                           168                           169                           218                           219
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           169                             1                             2                           169                           170                           219                           220
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           170                             1                             2                           170                           171                           220                           221
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           171                             1                             2                           171                           172                           221                           222
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           172                             1                             2                           172                           173                           222                           223
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           173                             1                             2                           173                           174                           223                           224
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           174                             1                             2                           174                           175                           224                           225
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           175                             1                             2                           175                           176                           225                           226
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           176                             1                             2                           176                           177                           226                           227
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           177                             1                             2                           177                           178                           227                           228
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           178                             1                             2                           178                           179                           228                           229
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           179                             1                             2                           179                           180                           229                           230
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           180                             1                             2                           180                           181                           230                           231
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           181                             1                             2                           181                           182                           231                           232
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           182                             1                             2                           182                           183                           232                           233
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           183                             1                             2                           183                           184                           233                           234
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           184                             1                             2                           184                           185                           234                           235
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           185                             1                             2                           185                           186                           235                           236
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           186                             1                             2                           186                           187                           236                           237
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           187                             1                             2                           187                           188                           237                           238
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           188                             1                             2                           188                           189                           238                           239
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           189                             1                             2                           189                           190                           239                           240
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           190                             1                             2                           190                           191                           240                           241
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           191                             1                             2                           191                           192                           241                           242
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           192                             1                             2                           192                           193                           242                           243
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           193                             1                             2                           193                           194                           243                           244
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           194                             1                             2                           194                           195                           244                           245
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           195                             1                             2                           195                           196                           245                           246
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           196                             1                             2                           196                           197                           246                           247
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           197                             1                             2                           197                           198                           247                           248
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           198                             1                             2                           198                           199                           248                           249
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           199                             1                             2                           199                           200                           249                           250
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           200                             1                             2                           200                           151                           250                           201
  0.4870337345666798239963E-01  0.3467957737943610369014E-01
                           201                             1                             2                           201                           202                           251                           252
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           202                             1                             2                           202                           203                           252                           253
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           203                             1                             2                           203                           204                           253                           254
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           204                             1                             2                           204                           205                           254                           255
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           205                             1                             2                           205                           206                           255                           256
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           206                             1                             2                           206                           207                           256                           257
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           207                             1                             2                           207                           208                           257                           258
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           208                             1                             2                           208                           209                           258                           259
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           209                             1                             2                           209                           210                           259                           260
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           210                             1                             2                           210                           211                           260                           261
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           211                             1                             2                           211                           212                           261                           262
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           212                             1                             2                           212                           213                           262                           263
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           213                             1                             2                           213                           214                           263                           264
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           214                             1                             2                           214                           215                           264                           265
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           215                             1                             2                           215                           216                           265                           266
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           216                             1                             2                           216                           217                           266                           267
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           217                             1                             2                           217                           218                           267                           268
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           218                             1                             2                           218                           219                           268                           269
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           219                             1                             2                           219                           220                           269                           270
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           220                             1                             2                           220                           221                           270                           271
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           221                             1                             2                           221                           222                           271                           272
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           222                             1                             2                           222                           223                           272                           273
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           223                             1                             2                           223                           224                           273                           274
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           224                             1                             2                           224                           225                           274                           275
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           225                             1                             2                           225                           226                           275                           276
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           226                             1                             2                           226                           227                           276                           277
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           227                             1                             2                           227                           228                           277                           278
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           228                             1                             2                           228                           229                           278                           279
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           229                             1                             2                           229                           230                           279                           280
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           230                             1                             2                           230                           231                           280                           281
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           231                             1                             2                           231                           232                           281                           282
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           232                             1                             2                           232                           233                           282                           283
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           233                             1                             2                           233                           234                           283                           284
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           234                             1                             2                           234                           235                           284                           285
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           235                             1                             2                           235                           236                           285                           286
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           236                             1                             2                           236                           237                           286                           287
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           237                             1                             2                           237                           238                           287                           288
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           238                             1                             2                           238                           239                           288                           289
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           239                             1                             2                           239                           240                           289                           290
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           240                             1                             2                           240                           241                           290                           291
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           241                             1                             2                           241                           242                           291                           292
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           242                             1                             2                           242                           243                           292                           293
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           243                             1                             2                           243                           244                           293                           294
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           244                             1                             2                           244                           245                           294                           295
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           245                             1                             2                           245                           246                           295                           296
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           246                             1                             2                           246                           247                           296                           297
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           247                             1                             2                           247                           248                           297                           298
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           248                             1                             2                           248                           249                           298                           299
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           249                             1                             2                           249                           250                           299                           300
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           250                             1                             2                           250                           201                           300                           251
  0.5230414630893809313505E-01  0.2375860203065026377001E-01
                           251                             1                             2                           251                           252                           301                           302
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           252                             1                             2                           252                           253                           302                           303
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           253                             1                             2                           253                           254                           303                           304
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           254                             1                             2                           254                           255                           304                           305
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           255                             1                             2                           255                           256                           305                           306
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           256                             1                             2                           256                           257                           306                           307
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           257                             1                             2                           257                           258                           307                           308
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           258                             1                             2                           258                           259                           308                           309
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           259                             1                             2                           259                           260                           309                           310
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           260                             1                             2                           260                           261                           310                           311
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           261                             1                             2                           261                           262                           311                           312
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           262                             1                             2                           262                           263                           312                           313
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           263                             1                             2                           263                           264                           313                           314
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           264                             1                             2                           264                           265                           314                           315
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           265                             1                             2                           265                           266                           315                           316
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           266                             1                             2                           266                           267                           316                           317
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           267                             1                             2                           267                           268                           317                           318
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           268                             1                             2                           268                           269                           318                           319
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           269                             1                             2                           269                           270                           319                           320
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           270                             1                             2                           270                           271                           320                           321
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           271                             1                             2                           271                           272                           321                           322
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           272                             1                             2                           272                           273                           322                           323
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           273                             1                             2                           273                           274                           323                           324
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           274                             1                             2                           274                           275                           324                           325
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           275                             1                             2                           275                           276                           325                           326
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           276                             1                             2                           276                           277                           326                           327
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           277                             1                             2                           277                           278                           327                           328
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           278                             1                             2                           278                           279                           328                           329
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           279                             1                             2                           279                           280                           329                           330
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           280                             1                             2                           280                           281                           330                           331
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           281                             1                             2                           281                           282                           331                           332
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           282                             1                             2                           282                           283                           332                           333
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           283                             1                             2                           283                           284                           333                           334
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           284                             1                             2                           284                           285                           334                           335
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           285                             1                             2                           285                           286                           335                           336
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           286                             1                             2                           286                           287                           336                           337
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           287                             1                             2                           287                           288                           337                           338
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           288                             1                             2                           288                           289                           338                           339
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           289                             1                             2                           289                           290                           339                           340
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           290                             1                             2                           290                           291                           340                           341
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           291                             1                             2                           291                           292                           341                           342
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           292                             1                             2                           292                           293                           342                           343
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           293                             1                             2                           293                           294                           343                           344
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           294                             1                             2                           294                           295                           344                           345
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           295                             1                             2                           295                           296                           345                           346
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           296                             1                             2                           296                           297                           346                           347
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           297                             1                             2                           297                           298                           347                           348
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           298                             1                             2                           298                           299                           348                           349
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           299                             1                             2                           299                           300                           349                           350
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           300                             1                             2                           300                           251                           350                           301
  0.5504597575877745452289E-01  0.2778396458607451310896E-01
                           301                             1                             3                           301                           302                           351                           352
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           302                             1                             3                           302                           303                           352                           353
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           303                             1                             3                           303                           304                           353                           354
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           304                             1                             3                           304                           305                           354                           355
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           305                             1                             3                           305                           306                           355                           356
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           306                             1                             3                           306                           307                           356                           357
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           307                             1                             3                           307                           308                           357                           358
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           308                             1                             3                           308                           309                           358                           359
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           309                             1                             3                           309                           310                           359                           360
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           310                             1                             3                           310                           311                           360                           361
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           311                             1                             3                           311                           312                           361                           362
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           312                             1                             3                           312                           313                           362                           363
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           313                             1                             3                           313                           314                           363                           364
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           314                             1                             3                           314                           315                           364                           365
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           315                             1                             3                           315                           316                           365                           366
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           316                             1                             3                           316                           317                           366                           367
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           317                             1                             3                           317                           318                           367                           368
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           318                             1                             3                           318                           319                           368                           369
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           319                             1                             3                           319                           320                           369                           370
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           320                             1                             3                           320                           321                           370                           371
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           321                             1                             3                           321                           322                           371                           372
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           322                             1                             3                           322                           323                           372                           373
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           323                             1                             3                           323                           324                           373                           374
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           324                             1                             3                           324                           325                           374                           375
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           325                             1                             3                           325                           326                           375                           376
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           326                             1                             3                           326                           327                           376                           377
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           327                             1                             3                           327                           328                           377                           378
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           328                             1                             3                           328                           329                           378                           379
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           329                             1                             3                           329                           330                           379                           380
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           330                             1                             3                           330                           331                           380                           381
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           331                             1                             3                           331                           332                           381                           382
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           332                             1                             3                           332                           333                           382                           383
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           333                             1                             3                           333                           334                           383                           384
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           334                             1                             3                           334                           335                           384                           385
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           335                             1                             3                           335                           336                           385                           386
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           336                             1                             3                           336                           337                           386                           387
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           337                             1                             3                           337                           338                           387                           388
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           338                             1                             3                           338                           339                           388                           389
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           339                             1                             3                           339                           340                           389                           390
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           340                             1                             3                           340                           341                           390                           391
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           341                             1                             3                           341                           342                           391                           392
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           342                             1                             3                           342                           343                           392                           393
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           343                             1                             3                           343                           344                           393                           394
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           344                             1                             3                           344                           345                           394                           395
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           345                             1                             3                           345                           346                           395                           396
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           346                             1                             3                           346                           347                           396                           397
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           347                             1                             3                           347                           348                           397                           398
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           348                             1                             3                           348                           349                           398                           399
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           349                             1                             3                           349                           350                           399                           400
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           350                             1                             3                           350                           301                           400                           351
  0.5721044933346192823409E-01  0.2497836844596585184619E-01
                           351                             1                             3                           351                           352                           401                           402
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           352                             1                             3                           352                           353                           402                           403
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           353                             1                             3                           353                           354                           403                           404
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           354                             1                             3                           354                           355                           404                           405
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           355                             1                             3                           355                           356                           405                           406
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           356                             1                             3                           356                           357                           406                           407
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           357                             1                             3                           357                           358                           407                           408
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           358                             1                             3                           358                           359                           408                           409
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           359                             1                             3                           359                           360                           409                           410
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           360                             1                             3                           360                           361                           410                           411
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           361                             1                             3                           361                           362                           411                           412
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           362                             1                             3                           362                           363                           412                           413
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           363                             1                             3                           363                           364                           413                           414
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           364                             1                             3                           364                           365                           414                           415
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           365                             1                             3                           365                           366                           415                           416
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           366                             1                             3                           366                           367                           416                           417
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           367                             1                             3                           367                           368                           417                           418
