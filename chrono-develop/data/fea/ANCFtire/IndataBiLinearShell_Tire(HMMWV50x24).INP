                           477                             0                             0                             0                             0                             0                             0
 -0.5848255626174198029688E-01 -0.6263164564168170744818E-01  0.9302371012593910748478E+00  0.1253316766278251281896E+00  0.4984435425738801585249E-02 -0.9921023768932039077484E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           478                             0                             0                             0                             0                             0                             0
 -0.1160428076754503878831E+00 -0.6263164564168170744818E-01  0.9192568960599605265571E+00  0.2486867978457144856552E+00  0.4984435425738802452611E-02 -0.9685711290249835458965E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           479                             0                             0                             0                             0                             0                             0
 -0.1717729946915039496158E+00 -0.6263164564168170744818E-01  0.9011490606237013700763E+00  0.3681199797032852494283E+00  0.4984435425738801585249E-02 -0.9297649358556920873298E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           480                             0                             0                             0                             0                             0                             0
 -0.2247942189690592396101E+00 -0.6263164564168170744818E-01  0.8761991663325399137818E+00  0.4817476895767184852382E+00  0.4984435425738802452611E-02 -0.8762957942333058358741E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           481                             0                             0                             0                             0                             0                             0
 -0.2742703041279148101772E+00 -0.6263164564168170744818E-01  0.8448006879237925925707E+00  0.5877779506034056522523E+00  0.4984435425738802452611E-02 -0.8090069444621269534323E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           482                             0                             0                             0                             0                             0                             0
 -0.3194209827495354536708E+00 -0.6263164564168170744818E-01  0.8074487981585066753709E+00  0.6845386022275496973322E+00  0.4984435425738802452611E-02 -0.7289595718994565931581E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           483                             0                             0                             0                             0                             0                             0
 -0.3595342016603500501226E+00 -0.6263164564168170744818E-01  0.7647325586512181416765E+00  0.7705036711710258057195E+00  0.4984435425738802452611E-02 -0.6374160714285906914611E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           484                             0                             0                             0                             0                             0                             0
 -0.3939773514356592065688E+00 -0.6263164564168170744818E-01  0.7173256300164017051912E+00  0.8443174369435517689908E+00  0.4984435425738802452611E-02 -0.5358201387373918711532E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           485                             0                             0                             0                             0                             0                             0
 -0.4222072430281661459261E+00 -0.6263164564168170744818E-01  0.6659756478381551048074E+00  0.9048158123646888872926E+00  0.4984435425738802452611E-02 -0.4257740023748685653793E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           486                             0                             0                             0                             0                             0                             0
 -0.4437786741837370652064E+00 -0.6263164564168170744818E-01  0.6114924320104218047334E+00  0.9510447019140677582527E+00  0.4984435425738802452611E-02 -0.3090131556498339482353E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           487                             0                             0                             0                             0                             0                             0
 -0.4583514505469005184679E+00 -0.6263164564168170744818E-01  0.5547352153935001251028E+00  0.9822750483876953042639E+00  0.4984435425738802452611E-02 -0.1873789868646891509929E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           488                             0                             0                             0                             0                             0                             0
 -0.4656957507290546693923E+00 -0.6263164564168170744818E-01  0.4965990931985569956097E+00  0.9980143305655774232932E+00  0.4984435425738802452611E-02 -0.6278973952190708418541E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           489                             0                             0                             0                             0                             0                             0
 -0.4656957507290546693923E+00 -0.6263164564168170744818E-01  0.4380009068014431017346E+00  0.9980143305655774232932E+00  0.4984435425738802452611E-02  0.6278973952190684826302E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           490                             0                             0                             0                             0                             0                             0
 -0.4583514505469005184679E+00 -0.6263164564168170744818E-01  0.3798647846064999722415E+00  0.9822750483876953042639E+00  0.4984435425738801585249E-02  0.1873789868646889011927E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           491                             0                             0                             0                             0                             0                             0
 -0.4437786741837371207176E+00 -0.6263164564168170744818E-01  0.3231075679895782926110E+00  0.9510447019140678692750E+00  0.4984435425738802452611E-02  0.3090131556498337261907E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           492                             0                             0                             0                             0                             0                             0
 -0.4222072430281662014373E+00 -0.6263164564168170744818E-01  0.2686243521618449925370E+00  0.9048158123646889983149E+00  0.4984435425738802452611E-02  0.4257740023748683433347E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           493                             0                             0                             0                             0                             0                             0
 -0.3939773514356590400354E+00 -0.6263164564168170744818E-01  0.2172743699835979480639E+00  0.8443174369435514359239E+00  0.4984435425738802452611E-02  0.5358201387373924262647E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           494                             0                             0                             0                             0                             0                             0
 -0.3595342016603501611449E+00 -0.6263164564168170744818E-01  0.1698674413487819556678E+00  0.7705036711710260277641E+00  0.4984435425738802452611E-02  0.6374160714285904694165E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           495                             0                             0                             0                             0                             0                             0
 -0.3194209827495357312266E+00 -0.6263164564168170744818E-01  0.1271512018414935329957E+00  0.6845386022275502524437E+00  0.4984435425738802452611E-02  0.7289595718994561490689E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           496                             0                             0                             0                             0                             0                             0
 -0.2742703041279150322218E+00 -0.6263164564168170744818E-01  0.8979931207620756028476E-01  0.5877779506034062073638E+00  0.4984435425738802452611E-02  0.8090069444621265093431E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           497                             0                             0                             0                             0                             0                             0
 -0.2247942189690595449214E+00 -0.6263164564168170744818E-01  0.5840083366746018356253E-01  0.4817476895767190958608E+00  0.4984435425738802452611E-02  0.8762957942333055028072E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           498                             0                             0                             0                             0                             0                             0
 -0.1717729946915038663491E+00 -0.6263164564168170744818E-01  0.3345093937629856073457E-01  0.3681199797032850828948E+00  0.4984435425738802452611E-02  0.9297649358556921983521E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           499                             0                             0                             0                             0                             0                             0
 -0.1160428076754507070723E+00 -0.6263164564168170744818E-01  0.1534310394003951527608E-01  0.2486867978457151517890E+00  0.4984435425738802452611E-02  0.9685711290249833238519E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           500                             0                             0                             0                             0                             0                             0
 -0.5848255626174208438028E-01 -0.6263164564168170744818E-01  0.4362898740608911474226E-02  0.1253316766278253502342E+00  0.4984435425738801585249E-02  0.9921023768932039077484E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           501                             0                             0                             0                             0                             0                             0
  0.2858577616120178179651E-16 -0.4175440864445545408046E-01  0.4588474145474363830033E-03 -0.6122590952006831116488E-16  0.1449217005109632895599E-01  0.9998949829893186702634E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           502                             0                             0                             0                             0                             0                             0
  0.5851071121442152911385E-01 -0.4175440864445545408046E-01  0.4140029341377138294433E-02 -0.1253200714427763207137E+00  0.1449217005109633069071E-01  0.9920105123942928315728E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           503                             0                             0                             0                             0                             0                             0
  0.1160986735603869307587E+00 -0.4175440864445545408046E-01  0.1512552068384875880724E-01 -0.2486637704963180206530E+00  0.1449217005109632722126E-01  0.9684814434204530586570E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           504                             0                             0                             0                             0                             0                             0
  0.1718556904703192611539E+00 -0.4175440864445545408046E-01  0.3324207368107695570458E-01 -0.3680858933445967373643E+00  0.1449217005109632895599E-01  0.9296788435411015294463E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           505                             0                             0                             0                             0                             0                             0
  0.2249024404799212784045E+00 -0.4175440864445545408046E-01  0.5820397946999134042301E-01 -0.4817030817709764267676E+00  0.1449217005109633069071E-01  0.8762146529358852964364E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           506                             0                             0                             0                             0                             0                             0
  0.2744023446529491594426E+00 -0.4175440864445545408046E-01  0.8961757388478092112294E-01 -0.5877235248423547941954E+00  0.1449217005109633069071E-01  0.8089320338286077882728E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           507                             0                             0                             0                             0                             0                             0
  0.3195747599307848796357E+00 -0.4175440864445545408046E-01  0.1269874457759528896261E+00 -0.6844752168379534262854E+00  0.1449217005109632722126E-01  0.7288920733152792763576E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           508                             0                             0                             0                             0                             0                             0
  0.3597072903398040866207E+00 -0.4175440864445545408046E-01  0.1697242499401040438656E+00 -0.7704323257783425304979E+00  0.1449217005109632722126E-01  0.6373570493867496411511E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           509                             0                             0                             0                             0                             0                             0
  0.3941670219014448695027E+00 -0.4175440864445545408046E-01  0.2171540014458362422012E+00 -0.8442392567072442011167E+00  0.1449217005109633069071E-01  0.5357705240507448785081E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           510                             0                             0                             0                             0                             0                             0
  0.4224105040637343155829E+00 -0.4175440864445545408046E-01  0.2685287047787440206648E+00 -0.9047320302337860109532E+00  0.1449217005109632895599E-01  0.4257345774966624363245E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           511                             0                             0                             0                             0                             0                             0
  0.4439923202411347191720E+00 -0.4175440864445545408046E-01  0.3230381501775072550231E+00 -0.9509566391828232490013E+00  0.1449217005109632722126E-01  0.3089845423339483976299E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           512                             0                             0                             0                             0                             0                             0
  0.4585721123001764709670E+00 -0.4175440864445545408046E-01  0.3798226911258230087398E+00 -0.9821840938579867730240E+00  0.1449217005109633069071E-01  0.1873616363602093326524E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           513                             0                             0                             0                             0                             0                             0
  0.4659199482105427225775E+00 -0.4175440864445545408046E-01  0.4379868014914959362116E+00 -0.9979219186446719458417E+00  0.1449217005109632895599E-01  0.6278392545665335833238E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           514                             0                             0                             0                             0                             0                             0
  0.4659199482105427225775E+00 -0.4175440864445545408046E-01  0.4966131985085040501104E+00 -0.9979219186446719458417E+00  0.1449217005109632895599E-01 -0.6278392545665335833238E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           515                             0                             0                             0                             0                             0                             0
  0.4585721123001764709670E+00 -0.4175440864445545408046E-01  0.5547773088741769775822E+00 -0.9821840938579867730240E+00  0.1449217005109633069071E-01 -0.1873616363602093326524E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           516                             0                             0                             0                             0                             0                             0
  0.4439923202411347746832E+00 -0.4175440864445545408046E-01  0.6115618498224926202766E+00 -0.9509566391828233600236E+00  0.1449217005109632895599E-01 -0.3089845423339481755853E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           517                             0                             0                             0                             0                             0                             0
  0.4224105040637342600718E+00 -0.4175440864445545408046E-01  0.6660712952212559656573E+00 -0.9047320302337858999309E+00  0.1449217005109633069071E-01 -0.4257345774966626028579E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           518                             0                             0                             0                             0                             0                             0
  0.3941670219014447584804E+00 -0.4175440864445545408046E-01  0.7174459985541639106543E+00 -0.8442392567072438680498E+00  0.1449217005109632722126E-01 -0.5357705240507452115750E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           519                             0                             0                             0                             0                             0                             0
  0.3597072903398040311096E+00 -0.4175440864445545408046E-01  0.7648757500598959424565E+00 -0.7704323257783424194756E+00  0.1449217005109632722126E-01 -0.6373570493867497521734E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           520                             0                             0                             0                             0                             0                             0
  0.3195747599307849906580E+00 -0.4175440864445545408046E-01  0.8076125542240469856736E+00 -0.6844752168379536483300E+00  0.1449217005109632722126E-01 -0.7288920733152790543130E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           521                             0                             0                             0                             0                             0                             0
  0.2744023446529491594426E+00 -0.4175440864445545408046E-01  0.8449824261152190096880E+00 -0.5877235248423547941954E+00  0.1449217005109633069071E-01 -0.8089320338286077882728E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           522                             0                             0                             0                             0                             0                             0
  0.2249024404799211951378E+00 -0.4175440864445545408046E-01  0.8763960205300087569213E+00 -0.4817030817709762602341E+00  0.1449217005109632895599E-01 -0.8762146529358854074587E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           523                             0                             0                             0                             0                             0                             0
  0.1718556904703192611539E+00 -0.4175440864445545408046E-01  0.9013579263189230861286E+00 -0.3680858933445967373643E+00  0.1449217005109632895599E-01 -0.9296788435411015294463E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           524                             0                             0                             0                             0                             0                             0
  0.1160986735603871389255E+00 -0.4175440864445545408046E-01  0.9194744793161511164925E+00 -0.2486637704963184647422E+00  0.1449217005109632722126E-01 -0.9684814434204529476347E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           525                             0                             0                             0                             0                             0                             0
  0.5851071121442163319726E-01 -0.4175440864445545408046E-01  0.9304599706586227370053E+00 -0.1253200714427765427583E+00  0.1449217005109632722126E-01 -0.9920105123942927205505E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           526                             0                             0                             0                             0                             0                             0
  0.2858577616120178179651E-16 -0.4175440864445545408046E-01  0.9341411525854526054502E+00 -0.6122590952006831116488E-16  0.1449217005109632895599E-01 -0.9998949829893186702634E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           527                             0                             0                             0                             0                             0                             0
 -0.5851071121442157768611E-01 -0.4175440864445545408046E-01  0.9304599706586227370053E+00  0.1253200714427764317360E+00  0.1449217005109632722126E-01 -0.9920105123942927205505E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           528                             0                             0                             0                             0                             0                             0
 -0.1160986735603868752476E+00 -0.4175440864445545408046E-01  0.9194744793161513385371E+00  0.2486637704963179096307E+00  0.1449217005109633069071E-01 -0.9684814434204531696793E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           529                             0                             0                             0                             0                             0                             0
 -0.1718556904703192056427E+00 -0.4175440864445545408046E-01  0.9013579263189230861286E+00  0.3680858933445966263420E+00  0.1449217005109632722126E-01 -0.9296788435411015294463E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           530                             0                             0                             0                             0                             0                             0
 -0.2249024404799213061601E+00 -0.4175440864445545408046E-01  0.8763960205300085348767E+00  0.4817030817709765377899E+00  0.1449217005109633069071E-01 -0.8762146529358851854141E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           531                             0                             0                             0                             0                             0                             0
 -0.2744023446529489929091E+00 -0.4175440864445545408046E-01  0.8449824261152192317326E+00  0.5877235248423543501062E+00  0.1449217005109633069071E-01 -0.8089320338286081213397E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           532                             0                             0                             0                             0                             0                             0
 -0.3195747599307847686134E+00 -0.4175440864445545408046E-01  0.8076125542240472077182E+00  0.6844752168379532042408E+00  0.1449217005109632722126E-01 -0.7288920733152794984022E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           533                             0                             0                             0                             0                             0                             0
 -0.3597072903398041421319E+00 -0.4175440864445545408046E-01  0.7648757500598959424565E+00  0.7704323257783426415202E+00  0.1449217005109632722126E-01 -0.6373570493867495301288E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           534                             0                             0                             0                             0                             0                             0
 -0.3941670219014449250139E+00 -0.4175440864445545408046E-01  0.7174459985541635775874E+00  0.8442392567072443121390E+00  0.1449217005109632722126E-01 -0.5357705240507445454412E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           535                             0                             0                             0                             0                             0                             0
 -0.4224105040637344266052E+00 -0.4175440864445545408046E-01  0.6660712952212557436127E+00  0.9047320302337862329978E+00  0.1449217005109632895599E-01 -0.4257345774966619367241E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           536                             0                             0                             0                             0                             0                             0
 -0.4439923202411347191720E+00 -0.4175440864445545408046E-01  0.6115618498224928423213E+00  0.9509566391828232490013E+00  0.1449217005109632895599E-01 -0.3089845423339485086522E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           537                             0                             0                             0                             0                             0                             0
 -0.4585721123001764709670E+00 -0.4175440864445545408046E-01  0.5547773088741769775822E+00  0.9821840938579867730240E+00  0.1449217005109632895599E-01 -0.1873616363602092493856E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           538                             0                             0                             0                             0                             0                             0
 -0.4659199482105427225775E+00 -0.4175440864445545408046E-01  0.4966131985085038835770E+00  0.9979219186446719458417E+00  0.1449217005109632895599E-01 -0.6278392545665303914326E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           539                             0                             0                             0                             0                             0                             0
 -0.4659199482105427225775E+00 -0.4175440864445545408046E-01  0.4379868014914962137674E+00  0.9979219186446719458417E+00  0.1449217005109632722126E-01  0.6278392545665280322087E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           540                             0                             0                             0                             0                             0                             0
 -0.4585721123001764709670E+00 -0.4175440864445545408046E-01  0.3798226911258231752733E+00  0.9821840938579867730240E+00  0.1449217005109632895599E-01  0.1873616363602089995855E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           541                             0                             0                             0                             0                             0                             0
 -0.4439923202411347746832E+00 -0.4175440864445545408046E-01  0.3230381501775072550231E+00  0.9509566391828233600236E+00  0.1449217005109633069071E-01  0.3089845423339482866076E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           542                             0                             0                             0                             0                             0                             0
 -0.4224105040637344821164E+00 -0.4175440864445545408046E-01  0.2685287047787443537317E+00  0.9047320302337863440201E+00  0.1449217005109632895599E-01  0.4257345774966617146795E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           543                             0                             0                             0                             0                             0                             0
 -0.3941670219014448139916E+00 -0.4175440864445545408046E-01  0.2171540014458361866900E+00  0.8442392567072439790721E+00  0.1449217005109632722126E-01  0.5357705240507451005527E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           544                             0                             0                             0                             0                             0                             0
 -0.3597072903398042531542E+00 -0.4175440864445545408046E-01  0.1697242499401042103990E+00  0.7704323257783428635648E+00  0.1449217005109633069071E-01  0.6373570493867493080842E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           545                             0                             0                             0                             0                             0                             0
 -0.3195747599307850461692E+00 -0.4175440864445545408046E-01  0.1269874457759530006484E+00  0.6844752168379537593523E+00  0.1449217005109633069071E-01  0.7288920733152790543130E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           546                             0                             0                             0                             0                             0                             0
 -0.2744023446529492149537E+00 -0.4175440864445545408046E-01  0.8961757388478097663409E-01  0.5877235248423549052177E+00  0.1449217005109633069071E-01  0.8089320338286076772505E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           547                             0                             0                             0                             0                             0                             0
 -0.2249024404799216114714E+00 -0.4175440864445545408046E-01  0.5820397946999150695646E-01  0.4817030817709771484125E+00  0.1449217005109632895599E-01  0.8762146529358848523472E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           548                             0                             0                             0                             0                             0                             0
 -0.1718556904703191501316E+00 -0.4175440864445545408046E-01  0.3324207368107690019343E-01  0.3680858933445964598086E+00  0.1449217005109632895599E-01  0.9296788435411016404686E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           549                             0                             0                             0                             0                             0                             0
 -0.1160986735603871944367E+00 -0.4175440864445545408046E-01  0.1512552068384881431840E-01  0.2486637704963185757645E+00  0.1449217005109632722126E-01  0.9684814434204529476347E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           550                             0                             0                             0                             0                             0                             0
 -0.5851071121442168176952E-01 -0.4175440864445545408046E-01  0.4140029341377193805585E-02  0.1253200714427766537806E+00  0.1449217005109632722126E-01  0.9920105123942927205505E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           551                             0                             0                             0                             0                             0                             0
  0.2860448741097507908179E-16 -0.2087723167897392873016E-01  0.1532695159022767761314E-03 -0.6122728769178313627970E-16  0.1284572727460347139894E-01  0.9999174902414631471714E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           552                             0                             0                             0                             0                             0                             0
  0.5854901028056451461890E-01 -0.2087723167897392873016E-01  0.3836861015734494007035E-02 -0.1253228923494662250260E+00  0.1284572727460347313366E-01  0.9920328421700315146836E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           553                             0                             0                             0                             0                             0                             0
  0.1161746676935210692561E+00 -0.2087723167897392873016E-01  0.1482954307680800498659E-01 -0.2486693678223142189854E+00  0.1284572727460346966422E-01  0.9685032435658834648606E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           554                             0                             0                             0                             0                             0                             0
  0.1719681811975683483062E+00 -0.2087723167897392873016E-01  0.3295795453630956384217E-01 -0.3680941788167245709573E+00  0.1284572727460347139894E-01  0.9296997702549074649170E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           555                             0                             0                             0                             0                             0                             0
  0.2250496537553178522106E+00 -0.2087723167897392873016E-01  0.5793619951613482310648E-01 -0.4817139247223909404028E+00  0.1284572727460347313366E-01  0.8762343761912889661403E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           556                             0                             0                             0                             0                             0                             0
  0.2745819588351993134623E+00 -0.2087723167897392873016E-01  0.8937035617167160550522E-01 -0.5877367542732349070533E+00  0.1284572727460347139894E-01  0.8089502425780893402063E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           557                             0                             0                             0                             0                             0                             0
  0.3197839423969381922319E+00 -0.2087723167897392873016E-01  0.1267646890746071952627E+00 -0.6844906241122713508318E+00  0.1284572727460346966422E-01  0.7289084803959821057262E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           558                             0                             0                             0                             0                             0                             0
  0.3599427421574097896162E+00 -0.2087723167897392873016E-01  0.1695294672567705940303E+00 -0.7704496679141783488376E+00  0.1284572727460346966422E-01  0.6373713960492098928867E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           559                             0                             0                             0                             0                             0                             0
  0.3944250298546872479655E+00 -0.2087723167897392873016E-01  0.2169902646197888196333E+00 -0.8442582602087560506021E+00  0.1284572727460347313366E-01  0.5357825840395252781079E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           560                             0                             0                             0                             0                             0                             0
  0.4226869992130641850991E+00 -0.2087723167897392873016E-01  0.2683985960375409596246E+00 -0.9047523954044029981247E+00  0.1284572727460347313366E-01  0.4257441606185355942316E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           561                             0                             0                             0                             0                             0                             0
  0.4442829420928769978971E+00 -0.2087723167897392873016E-01  0.3229437214137205192088E+00 -0.9509780448516391704317E+00  0.1284572727460346966422E-01  0.3089914974573577111094E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           562                             0                             0                             0                             0                             0                             0
  0.4588722775741200798905E+00 -0.2087723167897392873016E-01  0.3797654315374665578986E+00 -0.9822062024448172667945E+00  0.1284572727460347313366E-01  0.1873658537987038796846E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           563                             0                             0                             0                             0                             0                             0
  0.4662249231210075506304E+00 -0.2087723167897392873016E-01  0.4379676140964833264135E+00 -0.9979443814838956372526E+00  0.1284572727460347139894E-01  0.6278533869870868422414E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           564                             0                             0                             0                             0                             0                             0
  0.4662249231210075506304E+00 -0.2087723167897392873016E-01  0.4966323859035166599085E+00 -0.9979443814838956372526E+00  0.1284572727460347139894E-01 -0.6278533869870868422414E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           565                             0                             0                             0                             0                             0                             0
  0.4588722775741200798905E+00 -0.2087723167897392873016E-01  0.5548345684625334284235E+00 -0.9822062024448172667945E+00  0.1284572727460347313366E-01 -0.1873658537987038796846E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           566                             0                             0                             0                             0                             0                             0
  0.4442829420928770534083E+00 -0.2087723167897392873016E-01  0.6116562785862793560909E+00 -0.9509780448516392814540E+00  0.1284572727460347139894E-01 -0.3089914974573574890648E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           567                             0                             0                             0                             0                             0                             0
  0.4226869992130641295880E+00 -0.2087723167897392873016E-01  0.6662014039624590822086E+00 -0.9047523954044028871024E+00  0.1284572727460347313366E-01 -0.4257441606185357607650E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           568                             0                             0                             0                             0                             0                             0
  0.3944250298546870814320E+00 -0.2087723167897392873016E-01  0.7176097353802113332222E+00 -0.8442582602087557175352E+00  0.1284572727460346966422E-01 -0.5357825840395256111748E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           569                             0                             0                             0                             0                             0                             0
  0.3599427421574097341050E+00 -0.2087723167897392873016E-01  0.7650705327432294478029E+00 -0.7704496679141782378153E+00  0.1284572727460346966422E-01 -0.6373713960492100039090E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           570                             0                             0                             0                             0                             0                             0
  0.3197839423969383032542E+00 -0.2087723167897392873016E-01  0.8078353109253926245259E+00 -0.6844906241122715728764E+00  0.1284572727460347313366E-01 -0.7289084803959818836816E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           571                             0                             0                             0                             0                             0                             0
  0.2745819588351993134623E+00 -0.2087723167897392873016E-01  0.8452296438283284363280E+00 -0.5877367542732349070533E+00  0.1284572727460347139894E-01 -0.8089502425780893402063E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           572                             0                             0                             0                             0                             0                             0
  0.2250496537553177689439E+00 -0.2087723167897392873016E-01  0.8766638004838651632156E+00 -0.4817139247223907738693E+00  0.1284572727460347313366E-01 -0.8762343761912890771626E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           573                             0                             0                             0                             0                             0                             0
  0.1719681811975683483062E+00 -0.2087723167897392873016E-01  0.9016420454636904224799E+00 -0.3680941788167245709573E+00  0.1284572727460347139894E-01 -0.9296997702549074649170E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           574                             0                             0                             0                             0                             0                             0
  0.1161746676935212774229E+00 -0.2087723167897392873016E-01  0.9197704569231919258243E+00 -0.2486693678223146630746E+00  0.1284572727460346966422E-01 -0.9685032435658833538383E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           575                             0                             0                             0                             0                             0                             0
  0.5854901028056461176341E-01 -0.2087723167897392873016E-01  0.9307631389842654368039E+00 -0.1253228923494664470706E+00  0.1284572727460346966422E-01 -0.9920328421700314036613E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           576                             0                             0                             0                             0                             0                             0
  0.2860448741097507908179E-16 -0.2087723167897392873016E-01  0.9344467304840977650571E+00 -0.6122728769178313627970E-16  0.1284572727460347139894E-01 -0.9999174902414631471714E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           577                             0                             0                             0                             0                             0                             0
 -0.5854901028056456319115E-01 -0.2087723167897392873016E-01  0.9307631389842654368039E+00  0.1253228923494663360483E+00  0.1284572727460346966422E-01 -0.9920328421700314036613E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           578                             0                             0                             0                             0                             0                             0
 -0.1161746676935210137449E+00 -0.2087723167897392873016E-01  0.9197704569231920368466E+00  0.2486693678223141079631E+00  0.1284572727460347313366E-01 -0.9685032435658835758829E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           579                             0                             0                             0                             0                             0                             0
 -0.1719681811975682927951E+00 -0.2087723167897392873016E-01  0.9016420454636904224799E+00  0.3680941788167244599350E+00  0.1284572727460346966422E-01 -0.9296997702549074649170E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           580                             0                             0                             0                             0                             0                             0
 -0.2250496537553179077218E+00 -0.2087723167897392873016E-01  0.8766638004838651632156E+00  0.4817139247223910514251E+00  0.1284572727460347139894E-01 -0.8762343761912888551180E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           581                             0                             0                             0                             0                             0                             0
 -0.2745819588351991469288E+00 -0.2087723167897392873016E-01  0.8452296438283285473503E+00  0.5877367542732344629641E+00  0.1284572727460347313366E-01 -0.8089502425780896732732E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           582                             0                             0                             0                             0                             0                             0
 -0.3197839423969380812096E+00 -0.2087723167897392873016E-01  0.8078353109253928465705E+00  0.6844906241122711287872E+00  0.1284572727460347139894E-01 -0.7289084803959823277708E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           583                             0                             0                             0                             0                             0                             0
 -0.3599427421574098451273E+00 -0.2087723167897392873016E-01  0.7650705327432293367806E+00  0.7704496679141784598599E+00  0.1284572727460346966422E-01 -0.6373713960492097818644E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           584                             0                             0                             0                             0                             0                             0
 -0.3944250298546872479655E+00 -0.2087723167897392873016E-01  0.7176097353802110001553E+00  0.8442582602087561616244E+00  0.1284572727460346966422E-01 -0.5357825840395249450410E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           585                             0                             0                             0                             0                             0                             0
 -0.4226869992130642961214E+00 -0.2087723167897392873016E-01  0.6662014039624588601640E+00  0.9047523954044032201693E+00  0.1284572727460347139894E-01 -0.4257441606185350946312E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           586                             0                             0                             0                             0                             0                             0
 -0.4442829420928769978971E+00 -0.2087723167897392873016E-01  0.6116562785862795781355E+00  0.9509780448516391704317E+00  0.1284572727460346966422E-01 -0.3089914974573578221317E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           587                             0                             0                             0                             0                             0                             0
 -0.4588722775741200798905E+00 -0.2087723167897392873016E-01  0.5548345684625334284235E+00  0.9822062024448172667945E+00  0.1284572727460347313366E-01 -0.1873658537987037964179E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           588                             0                             0                             0                             0                             0                             0
 -0.4662249231210075506304E+00 -0.2087723167897392873016E-01  0.4966323859035164933751E+00  0.9979443814838956372526E+00  0.1284572727460346966422E-01 -0.6278533869870836503502E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           589                             0                             0                             0                             0                             0                             0
 -0.4662249231210075506304E+00 -0.2087723167897392873016E-01  0.4379676140964836039693E+00  0.9979443814838956372526E+00  0.1284572727460346966422E-01  0.6278533869870812911262E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           590                             0                             0                             0                             0                             0                             0
 -0.4588722775741200798905E+00 -0.2087723167897392873016E-01  0.3797654315374667244321E+00  0.9822062024448172667945E+00  0.1284572727460347139894E-01  0.1873658537987035466177E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           591                             0                             0                             0                             0                             0                             0
 -0.4442829420928770534083E+00 -0.2087723167897392873016E-01  0.3229437214137205192088E+00  0.9509780448516392814540E+00  0.1284572727460347139894E-01  0.3089914974573576000871E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           592                             0                             0                             0                             0                             0                             0
 -0.4226869992130643516326E+00 -0.2087723167897392873016E-01  0.2683985960375412926915E+00  0.9047523954044033311916E+00  0.1284572727460347139894E-01  0.4257441606185348725866E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           593                             0                             0                             0                             0                             0                             0
 -0.3944250298546871369432E+00 -0.2087723167897392873016E-01  0.2169902646197887086110E+00  0.8442582602087558285575E+00  0.1284572727460347139894E-01  0.5357825840395255001525E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           594                             0                             0                             0                             0                             0                             0
 -0.3599427421574099561496E+00 -0.2087723167897392873016E-01  0.1695294672567707605637E+00  0.7704496679141786819045E+00  0.1284572727460347313366E-01  0.6373713960492095598198E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           595                             0                             0                             0                             0                             0                             0
 -0.3197839423969383587654E+00 -0.2087723167897392873016E-01  0.1267646890746073062850E+00  0.6844906241122716838987E+00  0.1284572727460347313366E-01  0.7289084803959818836816E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           596                             0                             0                             0                             0                             0                             0
 -0.2745819588351993689734E+00 -0.2087723167897392873016E-01  0.8937035617167166101638E-01  0.5877367542732350180756E+00  0.1284572727460346966422E-01  0.8089502425780892291840E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           597                             0                             0                             0                             0                             0                             0
 -0.2250496537553181852775E+00 -0.2087723167897392873016E-01  0.5793619951613498963994E-01  0.4817139247223916620477E+00  0.1284572727460346966422E-01  0.8762343761912885220511E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           598                             0                             0                             0                             0                             0                             0
 -0.1719681811975682095284E+00 -0.2087723167897392873016E-01  0.3295795453630950833102E-01  0.3680941788167242934016E+00  0.1284572727460347139894E-01  0.9296997702549075759393E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           599                             0                             0                             0                             0                             0                             0
 -0.1161746676935213329340E+00 -0.2087723167897392873016E-01  0.1482954307680800498659E-01  0.2486693678223147740969E+00  0.1284572727460346966422E-01  0.9685032435658833538383E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           600                             0                             0                             0                             0                             0                             0
 -0.5854901028056466727456E-01 -0.2087723167897392873016E-01  0.3836861015734549518186E-02  0.1253228923494665580929E+00  0.1284572727460346966422E-01  0.9920328421700314036613E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           601                             0                             0                             0                             0                             0                             0
  0.2861387246207790657258E-16  0.0000000000000000000000E+00  0.0000000000000000000000E+00 -0.6123233995736766035869E-16 -0.1774356679499909638051E-16  0.1000000000000000000000E+01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           602                             0                             0                             0                             0                             0                             0
  0.5856822004459937697218E-01  0.0000000000000000000000E+00  0.3684800075744509850750E-02 -0.1253332335643042583229E+00 -0.1774356679499909946200E-16  0.9921147013144778759042E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           603                             0                             0                             0                             0                             0                             0
  0.1162127842721366183243E+00  0.0000000000000000000000E+00  0.1468108880459068066315E-01 -0.2486898871648547393320E+00 -0.1774356679499909638051E-16  0.9685831611286310760534E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           604                             0                             0                             0                             0                             0                             0
  0.1720246034695500636502E+00  0.0000000000000000000000E+00  0.3281544814442016733125E-01 -0.3681245526846780857788E+00 -0.1774356679499909638051E-16  0.9297764858882513472338E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           605                             0                             0                             0                             0                             0                             0
  0.2251234919077315654867E+00  0.0000000000000000000000E+00  0.5780188841550254474910E-01 -0.4817536741017153234523E+00 -0.1774356679499909946200E-16  0.8763066800438635839399E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           606                             0                             0                             0                             0                             0                             0
  0.2746720483962726833127E+00  0.0000000000000000000000E+00  0.8924635852858703310986E-01 -0.5877852522924731371035E+00 -0.1774356679499909946200E-16  0.8090169943749474512629E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           607                             0                             0                             0                             0                             0                             0
  0.3198888626004761648325E+00  0.0000000000000000000000E+00  0.1266529604059744018585E+00 -0.6845471059286886150730E+00 -0.1774356679499909329902E-16  0.7289686274214115524472E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           608                             0                             0                             0                             0                             0                             0
  0.3600608383491263331244E+00  0.0000000000000000000000E+00  0.1694317695904373199944E+00 -0.7705132427757892532583E+00 -0.1774356679499909329902E-16  0.6374239897486896344603E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           609                             0                             0                             0                             0                             0                             0
  0.3945544395870916876135E+00  0.0000000000000000000000E+00  0.2169081387063149235495E+00 -0.8443279255020151863320E+00 -0.1774356679499909946200E-16  0.5358267949789965456375E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           610                             0                             0                             0                             0                             0                             0
  0.4228256816173709409235E+00  0.0000000000000000000000E+00  0.2683333370516415294915E+00 -0.9048270524660195768263E+00 -0.1774356679499909638051E-16  0.4257792915650726039978E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           611                             0                             0                             0                             0                             0                             0
  0.4444287100647252297669E+00  0.0000000000000000000000E+00  0.3228963585285871129571E+00 -0.9510565162951535311819E+00 -0.1774356679499909329902E-16  0.3090169943749473957517E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           612                             0                             0                             0                             0                             0                             0
  0.4590228322655162118693E+00  0.0000000000000000000000E+00  0.3797367116940908449152E+00 -0.9822872507286887211464E+00 -0.1774356679499909638051E-16  0.1873813145857246564852E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           613                             0                             0                             0                             0                             0                             0
  0.4663778901945312971300E+00  0.0000000000000000000000E+00  0.4379579902239518207629E+00 -0.9980267284282715589683E+00 -0.1774356679499909638051E-16  0.6279051952931345714770E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           614                             0                             0                             0                             0                             0                             0
  0.4663778901945312971300E+00  0.0000000000000000000000E+00  0.4966420097760481655591E+00 -0.9980267284282715589683E+00 -0.1774356679499909638051E-16 -0.6279051952931345714770E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           615                             0                             0                             0                             0                             0                             0
  0.4590228322655162118693E+00  0.0000000000000000000000E+00  0.5548632883059091414069E+00 -0.9822872507286887211464E+00 -0.1774356679499909638051E-16 -0.1873813145857246564852E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           616                             0                             0                             0                             0                             0                             0
  0.4444287100647252852781E+00  0.0000000000000000000000E+00  0.6117036414714127623427E+00 -0.9510565162951536422042E+00 -0.1774356679499909638051E-16 -0.3090169943749471737071E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           617                             0                             0                             0                             0                             0                             0
  0.4228256816173708854123E+00  0.0000000000000000000000E+00  0.6662666629483584568305E+00 -0.9048270524660194658040E+00 -0.1774356679499909638051E-16 -0.4257792915650727705312E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           618                             0                             0                             0                             0                             0                             0
  0.3945544395870915210800E+00  0.0000000000000000000000E+00  0.7176918612936852293060E+00 -0.8443279255020148532651E+00 -0.1774356679499909329902E-16 -0.5358267949789968787044E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           619                             0                             0                             0                             0                             0                             0
  0.3600608383491262776133E+00  0.0000000000000000000000E+00  0.7651682304095627218388E+00 -0.7705132427757891422360E+00 -0.1774356679499909329902E-16 -0.6374239897486897454826E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           620                             0                             0                             0                             0                             0                             0
  0.3198888626004762758548E+00  0.0000000000000000000000E+00  0.8079470395940255844636E+00 -0.6845471059286888371176E+00 -0.1774356679499909329902E-16 -0.7289686274214113304026E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           621                             0                             0                             0                             0                             0                             0
  0.2746720483962726833127E+00  0.0000000000000000000000E+00  0.8453536414714128977010E+00 -0.5877852522924731371035E+00 -0.1774356679499909946200E-16 -0.8090169943749474512629E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           622                             0                             0                             0                             0                             0                             0
  0.2251234919077314822200E+00  0.0000000000000000000000E+00  0.8767981115844974970841E+00 -0.4817536741017151569189E+00 -0.1774356679499909638051E-16 -0.8763066800438636949622E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           623                             0                             0                             0                             0                             0                             0
  0.1720246034695500636502E+00  0.0000000000000000000000E+00  0.9017845518555798189908E+00 -0.3681245526846780857788E+00 -0.1774356679499909638051E-16 -0.9297764858882513472338E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           624                             0                             0                             0                             0                             0                             0
  0.1162127842721368264911E+00  0.0000000000000000000000E+00  0.9199189111954092501477E+00 -0.2486898871648551834213E+00 -0.1774356679499909638051E-16 -0.9685831611286309650310E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           625                             0                             0                             0                             0                             0                             0
  0.5856822004459948105559E-01  0.0000000000000000000000E+00  0.9309151999242554209602E+00 -0.1253332335643044803675E+00 -0.1774356679499909329902E-16 -0.9921147013144777648819E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           626                             0                             0                             0                             0                             0                             0
  0.2861387246207790657258E-16  0.0000000000000000000000E+00  0.9345999999999999863221E+00 -0.6123233995736766035869E-16 -0.1774356679499909638051E-16 -0.1000000000000000000000E+01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           627                             0                             0                             0                             0                             0                             0
 -0.5856822004459943248333E-01  0.0000000000000000000000E+00  0.9309151999242554209602E+00  0.1253332335643043693452E+00 -0.1774356679499909329902E-16 -0.9921147013144777648819E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           628                             0                             0                             0                             0                             0                             0
 -0.1162127842721365628131E+00  0.0000000000000000000000E+00  0.9199189111954093611701E+00  0.2486898871648546283097E+00 -0.1774356679499909638051E-16 -0.9685831611286311870757E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           629                             0                             0                             0                             0                             0                             0
 -0.1720246034695500081391E+00  0.0000000000000000000000E+00  0.9017845518555798189908E+00  0.3681245526846779747565E+00 -0.1774356679499909638051E-16 -0.9297764858882513472338E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           630                             0                             0                             0                             0                             0                             0
 -0.2251234919077316209979E+00  0.0000000000000000000000E+00  0.8767981115844973860618E+00  0.4817536741017154344746E+00 -0.1774356679499909638051E-16 -0.8763066800438634729176E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           631                             0                             0                             0                             0                             0                             0
 -0.2746720483962724612681E+00  0.0000000000000000000000E+00  0.8453536414714131197456E+00  0.5877852522924726930142E+00 -0.1774356679499909946200E-16 -0.8090169943749477843298E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           632                             0                             0                             0                             0                             0                             0
 -0.3198888626004760538102E+00  0.0000000000000000000000E+00  0.8079470395940256954859E+00  0.6845471059286883930284E+00 -0.1774356679499909638051E-16 -0.7289686274214117744918E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           633                             0                             0                             0                             0                             0                             0
 -0.3600608383491263886356E+00  0.0000000000000000000000E+00  0.7651682304095626108165E+00  0.7705132427757893642806E+00 -0.1774356679499909638051E-16 -0.6374239897486895234380E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           634                             0                             0                             0                             0                             0                             0
 -0.3945544395870917431246E+00  0.0000000000000000000000E+00  0.7176918612936848962391E+00  0.8443279255020152973543E+00 -0.1774356679499909329902E-16 -0.5358267949789962125706E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           635                             0                             0                             0                             0                             0                             0
 -0.4228256816173710519458E+00  0.0000000000000000000000E+00  0.6662666629483582347859E+00  0.9048270524660197988709E+00 -0.1774356679499909638051E-16 -0.4257792915650721043974E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           636                             0                             0                             0                             0                             0                             0
 -0.4444287100647252297669E+00  0.0000000000000000000000E+00  0.6117036414714129843873E+00  0.9510565162951535311819E+00 -0.1774356679499909329902E-16 -0.3090169943749475067740E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           637                             0                             0                             0                             0                             0                             0
 -0.4590228322655162118693E+00  0.0000000000000000000000E+00  0.5548632883059090303846E+00  0.9822872507286887211464E+00 -0.1774356679499909638051E-16 -0.1873813145857245732184E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           638                             0                             0                             0                             0                             0                             0
 -0.4663778901945312971300E+00  0.0000000000000000000000E+00  0.4966420097760479990256E+00  0.9980267284282715589683E+00 -0.1774356679499909638051E-16 -0.6279051952931313795858E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           639                             0                             0                             0                             0                             0                             0
 -0.4663778901945312971300E+00  0.0000000000000000000000E+00  0.4379579902239520983187E+00  0.9980267284282715589683E+00 -0.1774356679499909638051E-16  0.6279051952931290203619E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           640                             0                             0                             0                             0                             0                             0
 -0.4590228322655162118693E+00  0.0000000000000000000000E+00  0.3797367116940910114486E+00  0.9822872507286887211464E+00 -0.1774356679499909329902E-16  0.1873813145857243234182E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           641                             0                             0                             0                             0                             0                             0
 -0.4444287100647252852781E+00  0.0000000000000000000000E+00  0.3228963585285871129571E+00  0.9510565162951536422042E+00 -0.1774356679499909946200E-16  0.3090169943749472847294E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           642                             0                             0                             0                             0                             0                             0
 -0.4228256816173711074569E+00  0.0000000000000000000000E+00  0.2683333370516419180696E+00  0.9048270524660199098932E+00 -0.1774356679499909638051E-16  0.4257792915650718823528E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           643                             0                             0                             0                             0                             0                             0
 -0.3945544395870915765911E+00  0.0000000000000000000000E+00  0.2169081387063148125272E+00  0.8443279255020149642874E+00 -0.1774356679499909638051E-16  0.5358267949789967676821E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           644                             0                             0                             0                             0                             0                             0
 -0.3600608383491264441467E+00  0.0000000000000000000000E+00  0.1694317695904374865279E+00  0.7705132427757895863252E+00 -0.1774356679499909638051E-16  0.6374239897486893013934E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           645                             0                             0                             0                             0                             0                             0
 -0.3198888626004763313659E+00  0.0000000000000000000000E+00  0.1266529604059744573696E+00  0.6845471059286889481399E+00 -0.1774356679499909946200E-16  0.7289686274214113304026E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           646                             0                             0                             0                             0                             0                             0
 -0.2746720483962727388239E+00  0.0000000000000000000000E+00  0.8924635852858708862101E-01  0.5877852522924732481258E+00 -0.1774356679499909638051E-16  0.8090169943749473402406E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           647                             0                             0                             0                             0                             0                             0
 -0.2251234919077318985536E+00  0.0000000000000000000000E+00  0.5780188841550276679371E-01  0.4817536741017160450973E+00 -0.1774356679499909638051E-16  0.8763066800438631398507E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           648                             0                             0                             0                             0                             0                             0
 -0.1720246034695499248723E+00  0.0000000000000000000000E+00  0.3281544814442011182010E-01  0.3681245526846778082231E+00 -0.1774356679499909638051E-16  0.9297764858882514582561E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           649                             0                             0                             0                             0                             0                             0
 -0.1162127842721368820023E+00  0.0000000000000000000000E+00  0.1468108880459073617430E-01  0.2486898871648552944436E+00 -0.1774356679499909638051E-16  0.9685831611286309650310E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           650                             0                             0                             0                             0                             0                             0
 -0.5856822004459953656674E-01  0.0000000000000000000000E+00  0.3684800075744565361902E-02  0.1253332335643045913898E+00 -0.1774356679499909329902E-16  0.9921147013144777648819E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           651                             0                             0                             0                             0                             0                             0
