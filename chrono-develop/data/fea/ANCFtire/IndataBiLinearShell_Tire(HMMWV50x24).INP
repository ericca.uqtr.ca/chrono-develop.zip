  0.2860448741097507908179E-16  0.2087723167897390097458E-01  0.1532695159022767761314E-03 -0.6122728769178313627970E-16 -0.1284572727460344884753E-01  0.9999174902414631471714E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           652                             0                             0                             0                             0                             0                             0
  0.5854901028056451461890E-01  0.2087723167897390097458E-01  0.3836861015734494007035E-02 -0.1253228923494662250260E+00 -0.1284572727460345058226E-01  0.9920328421700315146836E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           653                             0                             0                             0                             0                             0                             0
  0.1161746676935210692561E+00  0.2087723167897390097458E-01  0.1482954307680800498659E-01 -0.2486693678223142189854E+00 -0.1284572727460344711281E-01  0.9685032435658834648606E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           654                             0                             0                             0                             0                             0                             0
  0.1719681811975683483062E+00  0.2087723167897390097458E-01  0.3295795453630956384217E-01 -0.3680941788167245709573E+00 -0.1284572727460344884753E-01  0.9296997702549074649170E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           655                             0                             0                             0                             0                             0                             0
  0.2250496537553178522106E+00  0.2087723167897390097458E-01  0.5793619951613482310648E-01 -0.4817139247223909404028E+00 -0.1284572727460344884753E-01  0.8762343761912889661403E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           656                             0                             0                             0                             0                             0                             0
  0.2745819588351993134623E+00  0.2087723167897390097458E-01  0.8937035617167160550522E-01 -0.5877367542732349070533E+00 -0.1284572727460344884753E-01  0.8089502425780893402063E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           657                             0                             0                             0                             0                             0                             0
  0.3197839423969381922319E+00  0.2087723167897390097458E-01  0.1267646890746071952627E+00 -0.6844906241122713508318E+00 -0.1284572727460344884753E-01  0.7289084803959821057262E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           658                             0                             0                             0                             0                             0                             0
  0.3599427421574097896162E+00  0.2087723167897390097458E-01  0.1695294672567705940303E+00 -0.7704496679141783488376E+00 -0.1284572727460344884753E-01  0.6373713960492098928867E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           659                             0                             0                             0                             0                             0                             0
  0.3944250298546872479655E+00  0.2087723167897390097458E-01  0.2169902646197888196333E+00 -0.8442582602087560506021E+00 -0.1284572727460344884753E-01  0.5357825840395252781079E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           660                             0                             0                             0                             0                             0                             0
  0.4226869992130641850991E+00  0.2087723167897390097458E-01  0.2683985960375409596246E+00 -0.9047523954044029981247E+00 -0.1284572727460344884753E-01  0.4257441606185355942316E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           661                             0                             0                             0                             0                             0                             0
  0.4442829420928769978971E+00  0.2087723167897390097458E-01  0.3229437214137205192088E+00 -0.9509780448516391704317E+00 -0.1284572727460344884753E-01  0.3089914974573577111094E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           662                             0                             0                             0                             0                             0                             0
  0.4588722775741200798905E+00  0.2087723167897390097458E-01  0.3797654315374665578986E+00 -0.9822062024448172667945E+00 -0.1284572727460345058226E-01  0.1873658537987038796846E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           663                             0                             0                             0                             0                             0                             0
  0.4662249231210075506304E+00  0.2087723167897390097458E-01  0.4379676140964833264135E+00 -0.9979443814838956372526E+00 -0.1284572727460344884753E-01  0.6278533869870868422414E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           664                             0                             0                             0                             0                             0                             0
  0.4662249231210075506304E+00  0.2087723167897390097458E-01  0.4966323859035166599085E+00 -0.9979443814838956372526E+00 -0.1284572727460344884753E-01 -0.6278533869870868422414E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           665                             0                             0                             0                             0                             0                             0
  0.4588722775741200798905E+00  0.2087723167897390097458E-01  0.5548345684625334284235E+00 -0.9822062024448172667945E+00 -0.1284572727460345058226E-01 -0.1873658537987038796846E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           666                             0                             0                             0                             0                             0                             0
  0.4442829420928770534083E+00  0.2087723167897390097458E-01  0.6116562785862793560909E+00 -0.9509780448516392814540E+00 -0.1284572727460345058226E-01 -0.3089914974573574890648E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           667                             0                             0                             0                             0                             0                             0
  0.4226869992130641295880E+00  0.2087723167897390097458E-01  0.6662014039624590822086E+00 -0.9047523954044028871024E+00 -0.1284572727460344884753E-01 -0.4257441606185357607650E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           668                             0                             0                             0                             0                             0                             0
  0.3944250298546870814320E+00  0.2087723167897390097458E-01  0.7176097353802113332222E+00 -0.8442582602087557175352E+00 -0.1284572727460344711281E-01 -0.5357825840395256111748E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           669                             0                             0                             0                             0                             0                             0
  0.3599427421574097341050E+00  0.2087723167897390097458E-01  0.7650705327432294478029E+00 -0.7704496679141782378153E+00 -0.1284572727460344711281E-01 -0.6373713960492100039090E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           670                             0                             0                             0                             0                             0                             0
  0.3197839423969383032542E+00  0.2087723167897390097458E-01  0.8078353109253926245259E+00 -0.6844906241122715728764E+00 -0.1284572727460344884753E-01 -0.7289084803959818836816E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           671                             0                             0                             0                             0                             0                             0
  0.2745819588351993134623E+00  0.2087723167897390097458E-01  0.8452296438283284363280E+00 -0.5877367542732349070533E+00 -0.1284572727460344884753E-01 -0.8089502425780893402063E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           672                             0                             0                             0                             0                             0                             0
  0.2250496537553177689439E+00  0.2087723167897390097458E-01  0.8766638004838651632156E+00 -0.4817139247223907738693E+00 -0.1284572727460344884753E-01 -0.8762343761912890771626E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           673                             0                             0                             0                             0                             0                             0
  0.1719681811975683483062E+00  0.2087723167897390097458E-01  0.9016420454636904224799E+00 -0.3680941788167245709573E+00 -0.1284572727460344884753E-01 -0.9296997702549074649170E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           674                             0                             0                             0                             0                             0                             0
  0.1161746676935212774229E+00  0.2087723167897390097458E-01  0.9197704569231919258243E+00 -0.2486693678223146630746E+00 -0.1284572727460344884753E-01 -0.9685032435658833538383E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           675                             0                             0                             0                             0                             0                             0
  0.5854901028056461176341E-01  0.2087723167897390097458E-01  0.9307631389842654368039E+00 -0.1253228923494664470706E+00 -0.1284572727460344711281E-01 -0.9920328421700314036613E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           676                             0                             0                             0                             0                             0                             0
  0.2860448741097507908179E-16  0.2087723167897390097458E-01  0.9344467304840977650571E+00 -0.6122728769178313627970E-16 -0.1284572727460344884753E-01 -0.9999174902414631471714E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           677                             0                             0                             0                             0                             0                             0
 -0.5854901028056456319115E-01  0.2087723167897390097458E-01  0.9307631389842654368039E+00  0.1253228923494663360483E+00 -0.1284572727460344711281E-01 -0.9920328421700314036613E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           678                             0                             0                             0                             0                             0                             0
 -0.1161746676935210137449E+00  0.2087723167897390097458E-01  0.9197704569231920368466E+00  0.2486693678223141079631E+00 -0.1284572727460344884753E-01 -0.9685032435658835758829E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           679                             0                             0                             0                             0                             0                             0
 -0.1719681811975682927951E+00  0.2087723167897390097458E-01  0.9016420454636904224799E+00  0.3680941788167244599350E+00 -0.1284572727460344711281E-01 -0.9296997702549074649170E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           680                             0                             0                             0                             0                             0                             0
 -0.2250496537553179077218E+00  0.2087723167897390097458E-01  0.8766638004838651632156E+00  0.4817139247223910514251E+00 -0.1284572727460344884753E-01 -0.8762343761912888551180E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           681                             0                             0                             0                             0                             0                             0
 -0.2745819588351991469288E+00  0.2087723167897390097458E-01  0.8452296438283285473503E+00  0.5877367542732344629641E+00 -0.1284572727460344884753E-01 -0.8089502425780896732732E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           682                             0                             0                             0                             0                             0                             0
 -0.3197839423969380812096E+00  0.2087723167897390097458E-01  0.8078353109253928465705E+00  0.6844906241122711287872E+00 -0.1284572727460344884753E-01 -0.7289084803959823277708E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           683                             0                             0                             0                             0                             0                             0
 -0.3599427421574098451273E+00  0.2087723167897390097458E-01  0.7650705327432293367806E+00  0.7704496679141784598599E+00 -0.1284572727460344884753E-01 -0.6373713960492097818644E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           684                             0                             0                             0                             0                             0                             0
 -0.3944250298546872479655E+00  0.2087723167897390097458E-01  0.7176097353802110001553E+00  0.8442582602087561616244E+00 -0.1284572727460344884753E-01 -0.5357825840395249450410E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           685                             0                             0                             0                             0                             0                             0
 -0.4226869992130642961214E+00  0.2087723167897390097458E-01  0.6662014039624588601640E+00  0.9047523954044032201693E+00 -0.1284572727460344884753E-01 -0.4257441606185350946312E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           686                             0                             0                             0                             0                             0                             0
 -0.4442829420928769978971E+00  0.2087723167897390097458E-01  0.6116562785862795781355E+00  0.9509780448516391704317E+00 -0.1284572727460344884753E-01 -0.3089914974573578221317E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           687                             0                             0                             0                             0                             0                             0
 -0.4588722775741200798905E+00  0.2087723167897390097458E-01  0.5548345684625334284235E+00  0.9822062024448172667945E+00 -0.1284572727460345058226E-01 -0.1873658537987037964179E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           688                             0                             0                             0                             0                             0                             0
 -0.4662249231210075506304E+00  0.2087723167897390097458E-01  0.4966323859035164933751E+00  0.9979443814838956372526E+00 -0.1284572727460344711281E-01 -0.6278533869870836503502E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           689                             0                             0                             0                             0                             0                             0
 -0.4662249231210075506304E+00  0.2087723167897390097458E-01  0.4379676140964836039693E+00  0.9979443814838956372526E+00 -0.1284572727460344711281E-01  0.6278533869870812911262E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           690                             0                             0                             0                             0                             0                             0
 -0.4588722775741200798905E+00  0.2087723167897390097458E-01  0.3797654315374667244321E+00  0.9822062024448172667945E+00 -0.1284572727460344884753E-01  0.1873658537987035466177E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           691                             0                             0                             0                             0                             0                             0
 -0.4442829420928770534083E+00  0.2087723167897390097458E-01  0.3229437214137205192088E+00  0.9509780448516392814540E+00 -0.1284572727460345058226E-01  0.3089914974573576000871E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           692                             0                             0                             0                             0                             0                             0
 -0.4226869992130643516326E+00  0.2087723167897390097458E-01  0.2683985960375412926915E+00  0.9047523954044033311916E+00 -0.1284572727460344884753E-01  0.4257441606185348725866E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           693                             0                             0                             0                             0                             0                             0
 -0.3944250298546871369432E+00  0.2087723167897390097458E-01  0.2169902646197887086110E+00  0.8442582602087558285575E+00 -0.1284572727460344711281E-01  0.5357825840395255001525E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           694                             0                             0                             0                             0                             0                             0
 -0.3599427421574099561496E+00  0.2087723167897390097458E-01  0.1695294672567707605637E+00  0.7704496679141786819045E+00 -0.1284572727460344884753E-01  0.6373713960492095598198E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           695                             0                             0                             0                             0                             0                             0
 -0.3197839423969383587654E+00  0.2087723167897390097458E-01  0.1267646890746073062850E+00  0.6844906241122716838987E+00 -0.1284572727460344884753E-01  0.7289084803959818836816E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           696                             0                             0                             0                             0                             0                             0
 -0.2745819588351993689734E+00  0.2087723167897390097458E-01  0.8937035617167166101638E-01  0.5877367542732350180756E+00 -0.1284572727460344884753E-01  0.8089502425780892291840E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           697                             0                             0                             0                             0                             0                             0
 -0.2250496537553181852775E+00  0.2087723167897390097458E-01  0.5793619951613498963994E-01  0.4817139247223916620477E+00 -0.1284572727460344884753E-01  0.8762343761912885220511E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           698                             0                             0                             0                             0                             0                             0
 -0.1719681811975682095284E+00  0.2087723167897390097458E-01  0.3295795453630950833102E-01  0.3680941788167242934016E+00 -0.1284572727460344884753E-01  0.9296997702549075759393E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           699                             0                             0                             0                             0                             0                             0
 -0.1161746676935213329340E+00  0.2087723167897390097458E-01  0.1482954307680800498659E-01  0.2486693678223147740969E+00 -0.1284572727460344884753E-01  0.9685032435658833538383E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           700                             0                             0                             0                             0                             0                             0
 -0.5854901028056466727456E-01  0.2087723167897390097458E-01  0.3836861015734549518186E-02  0.1253228923494665580929E+00 -0.1284572727460344711281E-01  0.9920328421700314036613E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           701                             0                             0                             0                             0                             0                             0
  0.2858577616120178179651E-16  0.4175440864445539856931E-01  0.4588474145474363830033E-03 -0.6122590952006831116488E-16 -0.1449217005109632722126E-01  0.9998949829893186702634E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           702                             0                             0                             0                             0                             0                             0
  0.5851071121442152911385E-01  0.4175440864445539856931E-01  0.4140029341377138294433E-02 -0.1253200714427763207137E+00 -0.1449217005109632895599E-01  0.9920105123942928315728E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           703                             0                             0                             0                             0                             0                             0
  0.1160986735603869307587E+00  0.4175440864445539856931E-01  0.1512552068384875880724E-01 -0.2486637704963180206530E+00 -0.1449217005109632548654E-01  0.9684814434204530586570E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           704                             0                             0                             0                             0                             0                             0
  0.1718556904703192611539E+00  0.4175440864445539856931E-01  0.3324207368107695570458E-01 -0.3680858933445967373643E+00 -0.1449217005109632722126E-01  0.9296788435411015294463E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           705                             0                             0                             0                             0                             0                             0
  0.2249024404799212784045E+00  0.4175440864445539856931E-01  0.5820397946999134042301E-01 -0.4817030817709764267676E+00 -0.1449217005109632722126E-01  0.8762146529358852964364E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           706                             0                             0                             0                             0                             0                             0
  0.2744023446529491594426E+00  0.4175440864445539856931E-01  0.8961757388478092112294E-01 -0.5877235248423547941954E+00 -0.1449217005109632722126E-01  0.8089320338286077882728E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           707                             0                             0                             0                             0                             0                             0
  0.3195747599307848796357E+00  0.4175440864445539856931E-01  0.1269874457759528896261E+00 -0.6844752168379534262854E+00 -0.1449217005109632548654E-01  0.7288920733152792763576E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           708                             0                             0                             0                             0                             0                             0
  0.3597072903398040866207E+00  0.4175440864445539856931E-01  0.1697242499401040438656E+00 -0.7704323257783425304979E+00 -0.1449217005109632722126E-01  0.6373570493867496411511E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           709                             0                             0                             0                             0                             0                             0
  0.3941670219014448695027E+00  0.4175440864445539856931E-01  0.2171540014458362422012E+00 -0.8442392567072442011167E+00 -0.1449217005109632722126E-01  0.5357705240507448785081E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           710                             0                             0                             0                             0                             0                             0
  0.4224105040637343155829E+00  0.4175440864445539856931E-01  0.2685287047787440206648E+00 -0.9047320302337860109532E+00 -0.1449217005109632895599E-01  0.4257345774966624363245E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           711                             0                             0                             0                             0                             0                             0
  0.4439923202411347191720E+00  0.4175440864445539856931E-01  0.3230381501775072550231E+00 -0.9509566391828232490013E+00 -0.1449217005109632548654E-01  0.3089845423339483976299E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           712                             0                             0                             0                             0                             0                             0
  0.4585721123001764709670E+00  0.4175440864445539856931E-01  0.3798226911258230087398E+00 -0.9821840938579867730240E+00 -0.1449217005109632722126E-01  0.1873616363602093326524E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           713                             0                             0                             0                             0                             0                             0
  0.4659199482105427225775E+00  0.4175440864445539856931E-01  0.4379868014914959362116E+00 -0.9979219186446719458417E+00 -0.1449217005109632722126E-01  0.6278392545665335833238E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           714                             0                             0                             0                             0                             0                             0
  0.4659199482105427225775E+00  0.4175440864445539856931E-01  0.4966131985085040501104E+00 -0.9979219186446719458417E+00 -0.1449217005109632722126E-01 -0.6278392545665335833238E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           715                             0                             0                             0                             0                             0                             0
  0.4585721123001764709670E+00  0.4175440864445539856931E-01  0.5547773088741769775822E+00 -0.9821840938579867730240E+00 -0.1449217005109632722126E-01 -0.1873616363602093326524E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           716                             0                             0                             0                             0                             0                             0
  0.4439923202411347746832E+00  0.4175440864445539856931E-01  0.6115618498224926202766E+00 -0.9509566391828233600236E+00 -0.1449217005109632722126E-01 -0.3089845423339481755853E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           717                             0                             0                             0                             0                             0                             0
  0.4224105040637342600718E+00  0.4175440864445539856931E-01  0.6660712952212559656573E+00 -0.9047320302337858999309E+00 -0.1449217005109632722126E-01 -0.4257345774966626028579E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           718                             0                             0                             0                             0                             0                             0
  0.3941670219014447584804E+00  0.4175440864445539856931E-01  0.7174459985541639106543E+00 -0.8442392567072438680498E+00 -0.1449217005109632722126E-01 -0.5357705240507452115750E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           719                             0                             0                             0                             0                             0                             0
  0.3597072903398040311096E+00  0.4175440864445539856931E-01  0.7648757500598959424565E+00 -0.7704323257783424194756E+00 -0.1449217005109632722126E-01 -0.6373570493867497521734E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           720                             0                             0                             0                             0                             0                             0
  0.3195747599307849906580E+00  0.4175440864445539856931E-01  0.8076125542240469856736E+00 -0.6844752168379536483300E+00 -0.1449217005109632722126E-01 -0.7288920733152790543130E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           721                             0                             0                             0                             0                             0                             0
  0.2744023446529491594426E+00  0.4175440864445539856931E-01  0.8449824261152190096880E+00 -0.5877235248423547941954E+00 -0.1449217005109632722126E-01 -0.8089320338286077882728E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           722                             0                             0                             0                             0                             0                             0
  0.2249024404799211951378E+00  0.4175440864445539856931E-01  0.8763960205300087569213E+00 -0.4817030817709762602341E+00 -0.1449217005109632895599E-01 -0.8762146529358854074587E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           723                             0                             0                             0                             0                             0                             0
  0.1718556904703192611539E+00  0.4175440864445539856931E-01  0.9013579263189230861286E+00 -0.3680858933445967373643E+00 -0.1449217005109632722126E-01 -0.9296788435411015294463E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           724                             0                             0                             0                             0                             0                             0
  0.1160986735603871389255E+00  0.4175440864445539856931E-01  0.9194744793161511164925E+00 -0.2486637704963184647422E+00 -0.1449217005109632548654E-01 -0.9684814434204529476347E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           725                             0                             0                             0                             0                             0                             0
  0.5851071121442163319726E-01  0.4175440864445539856931E-01  0.9304599706586227370053E+00 -0.1253200714427765427583E+00 -0.1449217005109632548654E-01 -0.9920105123942927205505E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           726                             0                             0                             0                             0                             0                             0
  0.2858577616120178179651E-16  0.4175440864445539856931E-01  0.9341411525854526054502E+00 -0.6122590952006831116488E-16 -0.1449217005109632722126E-01 -0.9998949829893186702634E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           727                             0                             0                             0                             0                             0                             0
 -0.5851071121442157768611E-01  0.4175440864445539856931E-01  0.9304599706586227370053E+00  0.1253200714427764317360E+00 -0.1449217005109632548654E-01 -0.9920105123942927205505E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           728                             0                             0                             0                             0                             0                             0
 -0.1160986735603868752476E+00  0.4175440864445539856931E-01  0.9194744793161513385371E+00  0.2486637704963179096307E+00 -0.1449217005109632722126E-01 -0.9684814434204531696793E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           729                             0                             0                             0                             0                             0                             0
 -0.1718556904703192056427E+00  0.4175440864445539856931E-01  0.9013579263189230861286E+00  0.3680858933445966263420E+00 -0.1449217005109632722126E-01 -0.9296788435411015294463E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           730                             0                             0                             0                             0                             0                             0
 -0.2249024404799213061601E+00  0.4175440864445539856931E-01  0.8763960205300085348767E+00  0.4817030817709765377899E+00 -0.1449217005109632722126E-01 -0.8762146529358851854141E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           731                             0                             0                             0                             0                             0                             0
 -0.2744023446529489929091E+00  0.4175440864445539856931E-01  0.8449824261152192317326E+00  0.5877235248423543501062E+00 -0.1449217005109632895599E-01 -0.8089320338286081213397E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           732                             0                             0                             0                             0                             0                             0
 -0.3195747599307847686134E+00  0.4175440864445539856931E-01  0.8076125542240472077182E+00  0.6844752168379532042408E+00 -0.1449217005109632722126E-01 -0.7288920733152794984022E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           733                             0                             0                             0                             0                             0                             0
 -0.3597072903398041421319E+00  0.4175440864445539856931E-01  0.7648757500598959424565E+00  0.7704323257783426415202E+00 -0.1449217005109632548654E-01 -0.6373570493867495301288E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           734                             0                             0                             0                             0                             0                             0
 -0.3941670219014449250139E+00  0.4175440864445539856931E-01  0.7174459985541635775874E+00  0.8442392567072443121390E+00 -0.1449217005109632548654E-01 -0.5357705240507445454412E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           735                             0                             0                             0                             0                             0                             0
 -0.4224105040637344266052E+00  0.4175440864445539856931E-01  0.6660712952212557436127E+00  0.9047320302337862329978E+00 -0.1449217005109632722126E-01 -0.4257345774966619367241E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           736                             0                             0                             0                             0                             0                             0
 -0.4439923202411347191720E+00  0.4175440864445539856931E-01  0.6115618498224928423213E+00  0.9509566391828232490013E+00 -0.1449217005109632722126E-01 -0.3089845423339485086522E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           737                             0                             0                             0                             0                             0                             0
 -0.4585721123001764709670E+00  0.4175440864445539856931E-01  0.5547773088741769775822E+00  0.9821840938579867730240E+00 -0.1449217005109632722126E-01 -0.1873616363602092493856E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           738                             0                             0                             0                             0                             0                             0
 -0.4659199482105427225775E+00  0.4175440864445539856931E-01  0.4966131985085038835770E+00  0.9979219186446719458417E+00 -0.1449217005109632722126E-01 -0.6278392545665303914326E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           739                             0                             0                             0                             0                             0                             0
 -0.4659199482105427225775E+00  0.4175440864445539856931E-01  0.4379868014914962137674E+00  0.9979219186446719458417E+00 -0.1449217005109632548654E-01  0.6278392545665280322087E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           740                             0                             0                             0                             0                             0                             0
 -0.4585721123001764709670E+00  0.4175440864445539856931E-01  0.3798226911258231752733E+00  0.9821840938579867730240E+00 -0.1449217005109632722126E-01  0.1873616363602089995855E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           741                             0                             0                             0                             0                             0                             0
 -0.4439923202411347746832E+00  0.4175440864445539856931E-01  0.3230381501775072550231E+00  0.9509566391828233600236E+00 -0.1449217005109632722126E-01  0.3089845423339482866076E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           742                             0                             0                             0                             0                             0                             0
 -0.4224105040637344821164E+00  0.4175440864445539856931E-01  0.2685287047787443537317E+00  0.9047320302337863440201E+00 -0.1449217005109632722126E-01  0.4257345774966617146795E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           743                             0                             0                             0                             0                             0                             0
 -0.3941670219014448139916E+00  0.4175440864445539856931E-01  0.2171540014458361866900E+00  0.8442392567072439790721E+00 -0.1449217005109632722126E-01  0.5357705240507451005527E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           744                             0                             0                             0                             0                             0                             0
 -0.3597072903398042531542E+00  0.4175440864445539856931E-01  0.1697242499401042103990E+00  0.7704323257783428635648E+00 -0.1449217005109632722126E-01  0.6373570493867493080842E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           745                             0                             0                             0                             0                             0                             0
 -0.3195747599307850461692E+00  0.4175440864445539856931E-01  0.1269874457759530006484E+00  0.6844752168379537593523E+00 -0.1449217005109632895599E-01  0.7288920733152790543130E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           746                             0                             0                             0                             0                             0                             0
 -0.2744023446529492149537E+00  0.4175440864445539856931E-01  0.8961757388478097663409E-01  0.5877235248423549052177E+00 -0.1449217005109632722126E-01  0.8089320338286076772505E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           747                             0                             0                             0                             0                             0                             0
 -0.2249024404799216114714E+00  0.4175440864445539856931E-01  0.5820397946999150695646E-01  0.4817030817709771484125E+00 -0.1449217005109632722126E-01  0.8762146529358848523472E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           748                             0                             0                             0                             0                             0                             0
 -0.1718556904703191501316E+00  0.4175440864445539856931E-01  0.3324207368107690019343E-01  0.3680858933445964598086E+00 -0.1449217005109632722126E-01  0.9296788435411016404686E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           749                             0                             0                             0                             0                             0                             0
 -0.1160986735603871944367E+00  0.4175440864445539856931E-01  0.1512552068384881431840E-01  0.2486637704963185757645E+00 -0.1449217005109632548654E-01  0.9684814434204529476347E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           750                             0                             0                             0                             0                             0                             0
 -0.5851071121442168176952E-01  0.4175440864445539856931E-01  0.4140029341377193805585E-02  0.1253200714427766537806E+00 -0.1449217005109632548654E-01  0.9920105123942927205505E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           751                             0                             0                             0                             0                             0                             0
  0.2857202088189609859734E-16  0.6263164564168170744818E-01  0.6834881732585285085690E-03 -0.6123157930625321031066E-16 -0.4984435425738811993590E-02  0.9999875776245855663049E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           752                             0                             0                             0                             0                             0                             0
  0.5848255626174192478572E-01  0.6263164564168170744818E-01  0.4362898740608855963075E-02 -0.1253316766278250171673E+00 -0.4984435425738812860952E-02  0.9921023768932040187707E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           753                             0                             0                             0                             0                             0                             0
  0.1160428076754504433943E+00  0.6263164564168170744818E-01  0.1534310394003945976493E-01 -0.2486867978457145966775E+00 -0.4984435425738811126228E-02  0.9685711290249834348742E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           754                             0                             0                             0                             0                             0                             0
  0.1717729946915040051270E+00  0.6263164564168170744818E-01  0.3345093937629861624572E-01 -0.3681199797032853604506E+00 -0.4984435425738812860952E-02  0.9297649358556920873298E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           755                             0                             0                             0                             0                             0                             0
  0.2247942189690592118545E+00  0.6263164564168170744818E-01  0.5840083366745996151792E-01 -0.4817476895767183742159E+00 -0.4984435425738811993590E-02  0.8762957942333059468965E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           756                             0                             0                             0                             0                             0                             0
  0.2742703041279150322218E+00  0.6263164564168170744818E-01  0.8979931207620750477361E-01 -0.5877779506034060963415E+00 -0.4984435425738811993590E-02  0.8090069444621266203654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           757                             0                             0                             0                             0                             0                             0
  0.3194209827495355646931E+00  0.6263164564168170744818E-01  0.1271512018414934219734E+00 -0.6845386022275499193768E+00 -0.4984435425738811993590E-02  0.7289595718994563711135E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           758                             0                             0                             0                             0                             0                             0
  0.3595342016603499946115E+00  0.6263164564168170744818E-01  0.1698674413487818446455E+00 -0.7705036711710256946972E+00 -0.4984435425738811993590E-02  0.6374160714285908024834E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           759                             0                             0                             0                             0                             0                             0
  0.3939773514356591510577E+00  0.6263164564168170744818E-01  0.2172743699835980590862E+00 -0.8443174369435516579685E+00 -0.4984435425738812860952E-02  0.5358201387373922042201E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           760                             0                             0                             0                             0                             0                             0
  0.4222072430281660349038E+00  0.6263164564168170744818E-01  0.2686243521618446594701E+00 -0.9048158123646886652480E+00 -0.4984435425738812860952E-02  0.4257740023748690649796E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           761                             0                             0                             0                             0                             0                             0
  0.4437786741837370652064E+00  0.6263164564168170744818E-01  0.3231075679895782926110E+00 -0.9510447019140677582527E+00 -0.4984435425738811126228E-02  0.3090131556498338372130E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           762                             0                             0                             0                             0                             0                             0
  0.4583514505469005184679E+00  0.6263164564168170744818E-01  0.3798647846064998612192E+00 -0.9822750483876953042639E+00 -0.4984435425738812860952E-02  0.1873789868646892342596E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           763                             0                             0                             0                             0                             0                             0
  0.4656957507290546693923E+00  0.6263164564168170744818E-01  0.4380009068014428796900E+00 -0.9980143305655774232932E+00 -0.4984435425738811993590E-02  0.6278973952190740337453E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           764                             0                             0                             0                             0                             0                             0
  0.4656957507290546693923E+00  0.6263164564168170744818E-01  0.4965990931985571066321E+00 -0.9980143305655774232932E+00 -0.4984435425738811993590E-02 -0.6278973952190740337453E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           765                             0                             0                             0                             0                             0                             0
  0.4583514505469005184679E+00  0.6263164564168170744818E-01  0.5547352153935001251028E+00 -0.9822750483876953042639E+00 -0.4984435425738812860952E-02 -0.1873789868646892342596E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           766                             0                             0                             0                             0                             0                             0
  0.4437786741837371207176E+00  0.6263164564168170744818E-01  0.6114924320104215826888E+00 -0.9510447019140678692750E+00 -0.4984435425738811993590E-02 -0.3090131556498336151684E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           767                             0                             0                             0                             0                             0                             0
  0.4222072430281659793927E+00  0.6263164564168170744818E-01  0.6659756478381553268520E+00 -0.9048158123646885542257E+00 -0.4984435425738811126228E-02 -0.4257740023748692315131E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           768                             0                             0                             0                             0                             0                             0
  0.3939773514356589845242E+00  0.6263164564168170744818E-01  0.7173256300164020382581E+00 -0.8443174369435513249016E+00 -0.4984435425738811126228E-02 -0.5358201387373925372870E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           769                             0                             0                             0                             0                             0                             0
  0.3595342016603499391003E+00  0.6263164564168170744818E-01  0.7647325586512181416765E+00 -0.7705036711710255836749E+00 -0.4984435425738811126228E-02 -0.6374160714285909135057E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           770                             0                             0                             0                             0                             0                             0
  0.3194209827495356757154E+00  0.6263164564168170744818E-01  0.8074487981585064533263E+00 -0.6845386022275501414214E+00 -0.4984435425738811126228E-02 -0.7289595718994561490689E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           771                             0                             0                             0                             0                             0                             0
  0.2742703041279150322218E+00  0.6263164564168170744818E-01  0.8448006879237924815484E+00 -0.5877779506034060963415E+00 -0.4984435425738811993590E-02 -0.8090069444621266203654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           772                             0                             0                             0                             0                             0                             0
  0.2247942189690591285878E+00  0.6263164564168170744818E-01  0.8761991663325401358264E+00 -0.4817476895767182076824E+00 -0.4984435425738812860952E-02 -0.8762957942333060579188E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           773                             0                             0                             0                             0                             0                             0
  0.1717729946915040051270E+00  0.6263164564168170744818E-01  0.9011490606237013700763E+00 -0.3681199797032853604506E+00 -0.4984435425738812860952E-02 -0.9297649358556920873298E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           774                             0                             0                             0                             0                             0                             0
  0.1160428076754506515611E+00  0.6263164564168170744818E-01  0.9192568960599605265571E+00 -0.2486867978457150407667E+00 -0.4984435425738811126228E-02 -0.9685711290249833238519E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           775                             0                             0                             0                             0                             0                             0
  0.5848255626174202886913E-01  0.6263164564168170744818E-01  0.9302371012593910748478E+00 -0.1253316766278252392119E+00 -0.4984435425738811126228E-02 -0.9921023768932039077484E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           776                             0                             0                             0                             0                             0                             0
  0.2857202088189609859734E-16  0.6263164564168170744818E-01  0.9339165118267414023023E+00 -0.6123157930625321031066E-16 -0.4984435425738811993590E-02 -0.9999875776245855663049E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           777                             0                             0                             0                             0                             0                             0
 -0.5848255626174198029688E-01  0.6263164564168170744818E-01  0.9302371012593910748478E+00  0.1253316766278251281896E+00 -0.4984435425738811126228E-02 -0.9921023768932039077484E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           778                             0                             0                             0                             0                             0                             0
 -0.1160428076754503878831E+00  0.6263164564168170744818E-01  0.9192568960599605265571E+00  0.2486867978457144856552E+00 -0.4984435425738811993590E-02 -0.9685711290249835458965E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           779                             0                             0                             0                             0                             0                             0
 -0.1717729946915039496158E+00  0.6263164564168170744818E-01  0.9011490606237013700763E+00  0.3681199797032852494283E+00 -0.4984435425738811993590E-02 -0.9297649358556920873298E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           780                             0                             0                             0                             0                             0                             0
 -0.2247942189690592396101E+00  0.6263164564168170744818E-01  0.8761991663325399137818E+00  0.4817476895767184852382E+00 -0.4984435425738811993590E-02 -0.8762957942333058358741E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           781                             0                             0                             0                             0                             0                             0
 -0.2742703041279148101772E+00  0.6263164564168170744818E-01  0.8448006879237925925707E+00  0.5877779506034056522523E+00 -0.4984435425738811993590E-02 -0.8090069444621269534323E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           782                             0                             0                             0                             0                             0                             0
 -0.3194209827495354536708E+00  0.6263164564168170744818E-01  0.8074487981585066753709E+00  0.6845386022275496973322E+00 -0.4984435425738811993590E-02 -0.7289595718994565931581E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           783                             0                             0                             0                             0                             0                             0
 -0.3595342016603500501226E+00  0.6263164564168170744818E-01  0.7647325586512181416765E+00  0.7705036711710258057195E+00 -0.4984435425738811993590E-02 -0.6374160714285906914611E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           784                             0                             0                             0                             0                             0                             0
 -0.3939773514356592065688E+00  0.6263164564168170744818E-01  0.7173256300164017051912E+00  0.8443174369435517689908E+00 -0.4984435425738811126228E-02 -0.5358201387373918711532E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           785                             0                             0                             0                             0                             0                             0
 -0.4222072430281661459261E+00  0.6263164564168170744818E-01  0.6659756478381551048074E+00  0.9048158123646888872926E+00 -0.4984435425738811993590E-02 -0.4257740023748685653793E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           786                             0                             0                             0                             0                             0                             0
 -0.4437786741837370652064E+00  0.6263164564168170744818E-01  0.6114924320104218047334E+00  0.9510447019140677582527E+00 -0.4984435425738811993590E-02 -0.3090131556498339482353E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           787                             0                             0                             0                             0                             0                             0
 -0.4583514505469005184679E+00  0.6263164564168170744818E-01  0.5547352153935001251028E+00  0.9822750483876953042639E+00 -0.4984435425738811993590E-02 -0.1873789868646891509929E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           788                             0                             0                             0                             0                             0                             0
 -0.4656957507290546693923E+00  0.6263164564168170744818E-01  0.4965990931985569956097E+00  0.9980143305655774232932E+00 -0.4984435425738811993590E-02 -0.6278973952190708418541E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           789                             0                             0                             0                             0                             0                             0
 -0.4656957507290546693923E+00  0.6263164564168170744818E-01  0.4380009068014431017346E+00  0.9980143305655774232932E+00 -0.4984435425738811993590E-02  0.6278973952190684826302E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           790                             0                             0                             0                             0                             0                             0
 -0.4583514505469005184679E+00  0.6263164564168170744818E-01  0.3798647846064999722415E+00  0.9822750483876953042639E+00 -0.4984435425738811993590E-02  0.1873789868646889011927E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           791                             0                             0                             0                             0                             0                             0
 -0.4437786741837371207176E+00  0.6263164564168170744818E-01  0.3231075679895782926110E+00  0.9510447019140678692750E+00 -0.4984435425738811993590E-02  0.3090131556498337261907E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           792                             0                             0                             0                             0                             0                             0
 -0.4222072430281662014373E+00  0.6263164564168170744818E-01  0.2686243521618449925370E+00  0.9048158123646889983149E+00 -0.4984435425738811993590E-02  0.4257740023748683433347E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           793                             0                             0                             0                             0                             0                             0
 -0.3939773514356590400354E+00  0.6263164564168170744818E-01  0.2172743699835979480639E+00  0.8443174369435514359239E+00 -0.4984435425738811126228E-02  0.5358201387373924262647E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           794                             0                             0                             0                             0                             0                             0
 -0.3595342016603501611449E+00  0.6263164564168170744818E-01  0.1698674413487819556678E+00  0.7705036711710260277641E+00 -0.4984435425738811993590E-02  0.6374160714285904694165E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           795                             0                             0                             0                             0                             0                             0
 -0.3194209827495357312266E+00  0.6263164564168170744818E-01  0.1271512018414935329957E+00  0.6845386022275502524437E+00 -0.4984435425738811993590E-02  0.7289595718994561490689E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           796                             0                             0                             0                             0                             0                             0
 -0.2742703041279150322218E+00  0.6263164564168170744818E-01  0.8979931207620756028476E-01  0.5877779506034062073638E+00 -0.4984435425738811993590E-02  0.8090069444621265093431E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           797                             0                             0                             0                             0                             0                             0
 -0.2247942189690595449214E+00  0.6263164564168170744818E-01  0.5840083366746018356253E-01  0.4817476895767190958608E+00 -0.4984435425738811993590E-02  0.8762957942333055028072E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           798                             0                             0                             0                             0                             0                             0
 -0.1717729946915038663491E+00  0.6263164564168170744818E-01  0.3345093937629856073457E-01  0.3681199797032850828948E+00 -0.4984435425738811126228E-02  0.9297649358556921983521E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           799                             0                             0                             0                             0                             0                             0
 -0.1160428076754507070723E+00  0.6263164564168170744818E-01  0.1534310394003951527608E-01  0.2486867978457151517890E+00 -0.4984435425738811993590E-02  0.9685711290249833238519E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           800                             0                             0                             0                             0                             0                             0
 -0.5848255626174208438028E-01  0.6263164564168170744818E-01  0.4362898740608911474226E-02  0.1253316766278253502342E+00 -0.4984435425738811126228E-02  0.9921023768932039077484E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           801                             0                             0                             0                             0                             0                             0
  0.2855786811015745030862E-16  0.8350873084007624791436E-01  0.9146204760335785444170E-03 -0.6113906976003831256862E-16 -0.5517350488583697143419E-01  0.9984767820828946982559E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           802                             0                             0                             0                             0                             0                             0
  0.5845358770285397076449E-01  0.8350873084007624791436E-01  0.4592208496140670614949E-02 -0.1251423237373303631870E+00 -0.5517350488583697143419E-01  0.9906034944256121299588E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           803                             0                             0                             0                             0                             0                             0
  0.1159853274091531549761E+00  0.8350873084007624791436E-01  0.1556697479650026583187E-01 -0.2483110782729223420251E+00 -0.5517350488583696449529E-01  0.9671077979033934068909E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           804                             0                             0                             0                             0                             0                             0
  0.1716879092159339648127E+00  0.8350873084007624791436E-01  0.3366584075654810437328E-01 -0.3675638187703024195585E+00 -0.5517350488583697143419E-01  0.9283602336860431458732E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           805                             0                             0                             0                             0                             0                             0
  0.2246828701329937338915E+00  0.8350873084007624791436E-01  0.5860337644835567072477E-01 -0.4810198582736922578995E+00 -0.5517350488583697837308E-01  0.8749718740079417411692E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           806                             0                             0                             0                             0                             0                             0
  0.2741344479690154267715E+00  0.8350873084007624791436E-01  0.8998630203710150654572E-01 -0.5868899272647709608464E+00 -0.5517350488583697143419E-01  0.8077846851938728089948E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           807                             0                             0                             0                             0                             0                             0
  0.3192627618005842715654E+00  0.8350873084007624791436E-01  0.1273196900390001218284E+00 -0.6835043915118355073446E+00 -0.5517350488583697143419E-01  0.7278582493471156267262E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           808                             0                             0                             0                             0                             0                             0
  0.3593561111602285307320E+00  0.8350873084007624791436E-01  0.1700147706233764988148E+00 -0.7693395831990262889732E+00 -0.5517350488583696449529E-01  0.6364530541067117130893E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           809                             0                             0                             0                             0                             0                             0
  0.3937821999779406167974E+00  0.8350873084007624791436E-01  0.2173982168646101387210E+00 -0.8430418300779781715093E+00 -0.5517350488583697143419E-01  0.5350106140044194047434E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           810                             0                             0                             0                             0                             0                             0
  0.4219981082679163941762E+00  0.8350873084007624791436E-01  0.2687227635099780354011E+00 -0.9034488036878217664949E+00 -0.5517350488583697837308E-01  0.4251307369194282648195E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           811                             0                             0                             0                             0                             0                             0
  0.4435588543010565154567E+00  0.8350873084007624791436E-01  0.3231789917990847693652E+00 -0.9496078499693529906267E+00 -0.5517350488583696449529E-01  0.3085462941524254598669E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           812                             0                             0                             0                             0                             0                             0
  0.4581244122326530443523E+00  0.8350873084007624791436E-01  0.3799080944812370796981E+00 -0.9807910131886347082641E+00 -0.5517350488583697837308E-01  0.1870958920100169453615E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           813                             0                             0                             0                             0                             0                             0
  0.4654650745130819999851E+00  0.8350873084007624791436E-01  0.4380154197188141362851E+00 -0.9965065162337796156322E+00 -0.5517350488583697143419E-01  0.6269487588494206120604E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           814                             0                             0                             0                             0                             0                             0
  0.4654650745130819999851E+00  0.8350873084007624791436E-01  0.4965845802811858500370E+00 -0.9965065162337796156322E+00 -0.5517350488583697143419E-01 -0.6269487588494206120604E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           815                             0                             0                             0                             0                             0                             0
  0.4581244122326530443523E+00  0.8350873084007624791436E-01  0.5546919055187629066239E+00 -0.9807910131886347082641E+00 -0.5517350488583697837308E-01 -0.1870958920100169453615E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           816                             0                             0                             0                             0                             0                             0
  0.4435588543010565709679E+00  0.8350873084007624791436E-01  0.6114210082009151614457E+00 -0.9496078499693531016490E+00 -0.5517350488583697143419E-01 -0.3085462941524252378223E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           817                             0                             0                             0                             0                             0                             0
  0.4219981082679163386651E+00  0.8350873084007624791436E-01  0.6658772364900220619433E+00 -0.9034488036878216554726E+00 -0.5517350488583697143419E-01 -0.4251307369194284313529E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           818                             0                             0                             0                             0                             0                             0
  0.3937821999779404502640E+00  0.8350873084007624791436E-01  0.7172017831353899586233E+00 -0.8430418300779778384424E+00 -0.5517350488583697143419E-01 -0.5350106140044197378103E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           819                             0                             0                             0                             0                             0                             0
  0.3593561111602284752209E+00  0.8350873084007624791436E-01  0.7645852293766235430184E+00 -0.7693395831990261779509E+00 -0.5517350488583696449529E-01 -0.6364530541067118241116E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           820                             0                             0                             0                             0                             0                             0
  0.3192627618005843825877E+00  0.8350873084007624791436E-01  0.8072803099609997534714E+00 -0.6835043915118357293892E+00 -0.5517350488583697143419E-01 -0.7278582493471154046816E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           821                             0                             0                             0                             0                             0                             0
  0.2741344479690154267715E+00  0.8350873084007624791436E-01  0.8446136979628984242652E+00 -0.5868899272647709608464E+00 -0.5517350488583697143419E-01 -0.8077846851938728089948E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           822                             0                             0                             0                             0                             0                             0
  0.2246828701329936506248E+00  0.8350873084007624791436E-01  0.8759966235516443155973E+00 -0.4810198582736920913661E+00 -0.5517350488583697143419E-01 -0.8749718740079418521915E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           823                             0                             0                             0                             0                             0                             0
  0.1716879092159339648127E+00  0.8350873084007624791436E-01  0.9009341592434518819488E+00 -0.3675638187703024195585E+00 -0.5517350488583697143419E-01 -0.9283602336860431458732E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           824                             0                             0                             0                             0                             0                             0
  0.1159853274091533631429E+00  0.8350873084007624791436E-01  0.9190330252034997204902E+00 -0.2483110782729227861143E+00 -0.5517350488583696449529E-01 -0.9671077979033932958686E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           825                             0                             0                             0                             0                             0                             0
  0.5845358770285406790901E-01  0.8350873084007624791436E-01  0.9300077915038592601960E+00 -0.1251423237373305852316E+00 -0.5517350488583696449529E-01 -0.9906034944256120189365E+00
