  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           368                             1                             3                           368                           369                           418                           419
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           369                             1                             3                           369                           370                           419                           420
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           370                             1                             3                           370                           371                           420                           421
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           371                             1                             3                           371                           372                           421                           422
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           372                             1                             3                           372                           373                           422                           423
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           373                             1                             3                           373                           374                           423                           424
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           374                             1                             3                           374                           375                           424                           425
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           375                             1                             3                           375                           376                           425                           426
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           376                             1                             3                           376                           377                           426                           427
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           377                             1                             3                           377                           378                           427                           428
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           378                             1                             3                           378                           379                           428                           429
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           379                             1                             3                           379                           380                           429                           430
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           380                             1                             3                           380                           381                           430                           431
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           381                             1                             3                           381                           382                           431                           432
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           382                             1                             3                           382                           383                           432                           433
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           383                             1                             3                           383                           384                           433                           434
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           384                             1                             3                           384                           385                           434                           435
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           385                             1                             3                           385                           386                           435                           436
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           386                             1                             3                           386                           387                           436                           437
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           387                             1                             3                           387                           388                           437                           438
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           388                             1                             3                           388                           389                           438                           439
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           389                             1                             3                           389                           390                           439                           440
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           390                             1                             3                           390                           391                           440                           441
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           391                             1                             3                           391                           392                           441                           442
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           392                             1                             3                           392                           393                           442                           443
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           393                             1                             3                           393                           394                           443                           444
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           394                             1                             3                           394                           395                           444                           445
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           395                             1                             3                           395                           396                           445                           446
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           396                             1                             3                           396                           397                           446                           447
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           397                             1                             3                           397                           398                           447                           448
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           398                             1                             3                           398                           399                           448                           449
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           399                             1                             3                           399                           400                           449                           450
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           400                             1                             3                           400                           351                           450                           401
  0.5834058645912798546362E-01  0.2130598452915481721970E-01
                           401                             1                             3                           401                           402                           451                           452
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           402                             1                             3                           402                           403                           452                           453
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           403                             1                             3                           403                           404                           453                           454
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           404                             1                             3                           404                           405                           454                           455
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           405                             1                             3                           405                           406                           455                           456
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           406                             1                             3                           406                           407                           456                           457
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           407                             1                             3                           407                           408                           457                           458
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           408                             1                             3                           408                           409                           458                           459
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           409                             1                             3                           409                           410                           459                           460
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           410                             1                             3                           410                           411                           460                           461
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           411                             1                             3                           411                           412                           461                           462
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           412                             1                             3                           412                           413                           462                           463
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           413                             1                             3                           413                           414                           463                           464
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           414                             1                             3                           414                           415                           464                           465
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           415                             1                             3                           415                           416                           465                           466
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           416                             1                             3                           416                           417                           466                           467
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           417                             1                             3                           417                           418                           467                           468
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           418                             1                             3                           418                           419                           468                           469
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           419                             1                             3                           419                           420                           469                           470
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           420                             1                             3                           420                           421                           470                           471
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           421                             1                             3                           421                           422                           471                           472
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           422                             1                             3                           422                           423                           472                           473
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           423                             1                             3                           423                           424                           473                           474
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           424                             1                             3                           424                           425                           474                           475
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           425                             1                             3                           425                           426                           475                           476
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           426                             1                             3                           426                           427                           476                           477
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           427                             1                             3                           427                           428                           477                           478
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           428                             1                             3                           428                           429                           478                           479
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           429                             1                             3                           429                           430                           479                           480
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           430                             1                             3                           430                           431                           480                           481
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           431                             1                             3                           431                           432                           481                           482
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           432                             1                             3                           432                           433                           482                           483
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           433                             1                             3                           433                           434                           483                           484
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           434                             1                             3                           434                           435                           484                           485
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           435                             1                             3                           435                           436                           485                           486
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           436                             1                             3                           436                           437                           486                           487
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           437                             1                             3                           437                           438                           487                           488
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           438                             1                             3                           438                           439                           488                           489
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           439                             1                             3                           439                           440                           489                           490
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           440                             1                             3                           440                           441                           490                           491
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           441                             1                             3                           441                           442                           491                           492
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           442                             1                             3                           442                           443                           492                           493
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           443                             1                             3                           443                           444                           493                           494
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           444                             1                             3                           444                           445                           494                           495
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           445                             1                             3                           445                           446                           495                           496
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           446                             1                             3                           446                           447                           496                           497
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           447                             1                             3                           447                           448                           497                           498
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           448                             1                             3                           448                           449                           498                           499
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           449                             1                             3                           449                           450                           499                           500
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           450                             1                             3                           450                           401                           500                           451
  0.5862223775305532014190E-01  0.2087836460363725124556E-01
                           451                             1                             3                           451                           452                           501                           502
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           452                             1                             3                           452                           453                           502                           503
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           453                             1                             3                           453                           454                           503                           504
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           454                             1                             3                           454                           455                           504                           505
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           455                             1                             3                           455                           456                           505                           506
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           456                             1                             3                           456                           457                           506                           507
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           457                             1                             3                           457                           458                           507                           508
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           458                             1                             3                           458                           459                           508                           509
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           459                             1                             3                           459                           460                           509                           510
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           460                             1                             3                           460                           461                           510                           511
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           461                             1                             3                           461                           462                           511                           512
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           462                             1                             3                           462                           463                           512                           513
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           463                             1                             3                           463                           464                           513                           514
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           464                             1                             3                           464                           465                           514                           515
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           465                             1                             3                           465                           466                           515                           516
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           466                             1                             3                           466                           467                           516                           517
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           467                             1                             3                           467                           468                           517                           518
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           468                             1                             3                           468                           469                           518                           519
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           469                             1                             3                           469                           470                           519                           520
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           470                             1                             3                           470                           471                           520                           521
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           471                             1                             3                           471                           472                           521                           522
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           472                             1                             3                           472                           473                           522                           523
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           473                             1                             3                           473                           474                           523                           524
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           474                             1                             3                           474                           475                           524                           525
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           475                             1                             3                           475                           476                           525                           526
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           476                             1                             3                           476                           477                           526                           527
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           477                             1                             3                           477                           478                           527                           528
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           478                             1                             3                           478                           479                           528                           529
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           479                             1                             3                           479                           480                           529                           530
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           480                             1                             3                           480                           481                           530                           531
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           481                             1                             3                           481                           482                           531                           532
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           482                             1                             3                           482                           483                           532                           533
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           483                             1                             3                           483                           484                           533                           534
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           484                             1                             3                           484                           485                           534                           535
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           485                             1                             3                           485                           486                           535                           536
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           486                             1                             3                           486                           487                           536                           537
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           487                             1                             3                           487                           488                           537                           538
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           488                             1                             3                           488                           489                           538                           539
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           489                             1                             3                           489                           490                           539                           540
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           490                             1                             3                           490                           491                           540                           541
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           491                             1                             3                           491                           492                           541                           542
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           492                             1                             3                           492                           493                           542                           543
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           493                             1                             3                           493                           494                           543                           544
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           494                             1                             3                           494                           495                           544                           545
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           495                             1                             3                           495                           496                           545                           546
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           496                             1                             3                           496                           497                           546                           547
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           497                             1                             3                           497                           498                           547                           548
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           498                             1                             3                           498                           499                           548                           549
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           499                             1                             3                           499                           500                           549                           550
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           500                             1                             3                           500                           451                           550                           501
  0.5865087481908870525871E-01  0.2087844553861295179842E-01
                           501                             1                             3                           501                           502                           551                           552
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           502                             1                             3                           502                           503                           552                           553
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           503                             1                             3                           503                           504                           553                           554
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           504                             1                             3                           504                           505                           554                           555
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           505                             1                             3                           505                           506                           555                           556
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           506                             1                             3                           506                           507                           556                           557
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           507                             1                             3                           507                           508                           557                           558
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           508                             1                             3                           508                           509                           558                           559
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           509                             1                             3                           509                           510                           559                           560
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           510                             1                             3                           510                           511                           560                           561
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           511                             1                             3                           511                           512                           561                           562
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           512                             1                             3                           512                           513                           562                           563
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           513                             1                             3                           513                           514                           563                           564
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           514                             1                             3                           514                           515                           564                           565
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           515                             1                             3                           515                           516                           565                           566
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           516                             1                             3                           516                           517                           566                           567
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           517                             1                             3                           517                           518                           567                           568
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           518                             1                             3                           518                           519                           568                           569
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           519                             1                             3                           519                           520                           569                           570
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           520                             1                             3                           520                           521                           570                           571
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           521                             1                             3                           521                           522                           571                           572
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           522                             1                             3                           522                           523                           572                           573
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           523                             1                             3                           523                           524                           573                           574
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           524                             1                             3                           524                           525                           574                           575
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           525                             1                             3                           525                           526                           575                           576
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           526                             1                             3                           526                           527                           576                           577
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           527                             1                             3                           527                           528                           577                           578
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           528                             1                             3                           528                           529                           578                           579
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           529                             1                             3                           529                           530                           579                           580
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           530                             1                             3                           530                           531                           580                           581
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           531                             1                             3                           531                           532                           581                           582
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           532                             1                             3                           532                           533                           582                           583
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           533                             1                             3                           533                           534                           583                           584
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           534                             1                             3                           534                           535                           584                           585
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           535                             1                             3                           535                           536                           585                           586
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           536                             1                             3                           536                           537                           586                           587
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           537                             1                             3                           537                           538                           587                           588
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           538                             1                             3                           538                           539                           588                           589
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           539                             1                             3                           539                           540                           589                           590
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           540                             1                             3                           540                           541                           590                           591
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           541                             1                             3                           541                           542                           591                           592
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           542                             1                             3                           542                           543                           592                           593
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           543                             1                             3                           543                           544                           593                           594
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           544                             1                             3                           544                           545                           594                           595
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           545                             1                             3                           545                           546                           595                           596
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           546                             1                             3                           546                           547                           596                           597
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           547                             1                             3                           547                           548                           597                           598
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           548                             1                             3                           548                           549                           598                           599
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           549                             1                             3                           549                           550                           599                           600
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           550                             1                             3                           550                           501                           600                           551
  0.5868418943986364322285E-01  0.2087941320775497239248E-01
                           551                             1                             3                           551                           552                           601                           602
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           552                             1                             3                           552                           553                           602                           603
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           553                             1                             3                           553                           554                           603                           604
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           554                             1                             3                           554                           555                           604                           605
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           555                             1                             3                           555                           556                           605                           606
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           556                             1                             3                           556                           557                           606                           607
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           557                             1                             3                           557                           558                           607                           608
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           558                             1                             3                           558                           559                           608                           609
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           559                             1                             3                           559                           560                           609                           610
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           560                             1                             3                           560                           561                           610                           611
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           561                             1                             3                           561                           562                           611                           612
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           562                             1                             3                           562                           563                           612                           613
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           563                             1                             3                           563                           564                           613                           614
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           564                             1                             3                           564                           565                           614                           615
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           565                             1                             3                           565                           566                           615                           616
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           566                             1                             3                           566                           567                           616                           617
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           567                             1                             3                           567                           568                           617                           618
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           568                             1                             3                           568                           569                           618                           619
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           569                             1                             3                           569                           570                           619                           620
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           570                             1                             3                           570                           571                           620                           621
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           571                             1                             3                           571                           572                           621                           622
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           572                             1                             3                           572                           573                           622                           623
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           573                             1                             3                           573                           574                           623                           624
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           574                             1                             3                           574                           575                           624                           625
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           575                             1                             3                           575                           576                           625                           626
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           576                             1                             3                           576                           577                           626                           627
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           577                             1                             3                           577                           578                           627                           628
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           578                             1                             3                           578                           579                           628                           629
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           579                             1                             3                           579                           580                           629                           630
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           580                             1                             3                           580                           581                           630                           631
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           581                             1                             3                           581                           582                           631                           632
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           582                             1                             3                           582                           583                           632                           633
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           583                             1                             3                           583                           584                           633                           634
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           584                             1                             3                           584                           585                           634                           635
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           585                             1                             3                           585                           586                           635                           636
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           586                             1                             3                           586                           587                           636                           637
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           587                             1                             3                           587                           588                           637                           638
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           588                             1                             3                           588                           589                           638                           639
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           589                             1                             3                           589                           590                           639                           640
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           590                             1                             3                           590                           591                           640                           641
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           591                             1                             3                           591                           592                           641                           642
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           592                             1                             3                           592                           593                           642                           643
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           593                             1                             3                           593                           594                           643                           644
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           594                             1                             3                           594                           595                           644                           645
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           595                             1                             3                           595                           596                           645                           646
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           596                             1                             3                           596                           597                           646                           647
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           597                             1                             3                           597                           598                           647                           648
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           598                             1                             3                           598                           599                           648                           649
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           599                             1                             3                           599                           600                           649                           650
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           600                             1                             3                           600                           551                           650                           601
  0.5871301967319685066737E-01  0.2087779428297101974588E-01
                           601                             1                             3                           601                           602                           651                           652
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           602                             1                             3                           602                           603                           652                           653
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           603                             1                             3                           603                           604                           653                           654
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           604                             1                             3                           604                           605                           654                           655
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           605                             1                             3                           605                           606                           655                           656
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           606                             1                             3                           606                           607                           656                           657
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           607                             1                             3                           607                           608                           657                           658
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           608                             1                             3                           608                           609                           658                           659
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           609                             1                             3                           609                           610                           659                           660
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           610                             1                             3                           610                           611                           660                           661
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           611                             1                             3                           611                           612                           661                           662
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           612                             1                             3                           612                           613                           662                           663
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           613                             1                             3                           613                           614                           663                           664
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           614                             1                             3                           614                           615                           664                           665
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           615                             1                             3                           615                           616                           665                           666
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           616                             1                             3                           616                           617                           666                           667
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           617                             1                             3                           617                           618                           667                           668
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           618                             1                             3                           618                           619                           668                           669
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           619                             1                             3                           619                           620                           669                           670
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           620                             1                             3                           620                           621                           670                           671
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           621                             1                             3                           621                           622                           671                           672
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           622                             1                             3                           622                           623                           672                           673
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           623                             1                             3                           623                           624                           673                           674
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           624                             1                             3                           624                           625                           674                           675
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           625                             1                             3                           625                           626                           675                           676
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           626                             1                             3                           626                           627                           676                           677
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           627                             1                             3                           627                           628                           677                           678
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           628                             1                             3                           628                           629                           678                           679
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           629                             1                             3                           629                           630                           679                           680
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           630                             1                             3                           630                           631                           680                           681
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           631                             1                             3                           631                           632                           681                           682
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           632                             1                             3                           632                           633                           682                           683
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           633                             1                             3                           633                           634                           683                           684
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           634                             1                             3                           634                           635                           684                           685
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           635                             1                             3                           635                           636                           685                           686
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           636                             1                             3                           636                           637                           686                           687
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           637                             1                             3                           637                           638                           687                           688
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           638                             1                             3                           638                           639                           688                           689
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           639                             1                             3                           639                           640                           689                           690
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           640                             1                             3                           640                           641                           690                           691
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           641                             1                             3                           641                           642                           691                           692
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           642                             1                             3                           642                           643                           692                           693
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           643                             1                             3                           643                           644                           693                           694
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           644                             1                             3                           644                           645                           694                           695
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           645                             1                             3                           645                           646                           695                           696
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           646                             1                             3                           646                           647                           696                           697
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           647                             1                             3                           647                           648                           697                           698
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           648                             1                             3                           648                           649                           698                           699
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           649                             1                             3                           649                           650                           699                           700
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           650                             1                             3                           650                           601                           700                           651
  0.5871301967319685066737E-01  0.2087779428297099545975E-01
                           651                             1                             3                           651                           652                           701                           702
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           652                             1                             3                           652                           653                           702                           703
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           653                             1                             3                           653                           654                           703                           704
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           654                             1                             3                           654                           655                           704                           705
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           655                             1                             3                           655                           656                           705                           706
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           656                             1                             3                           656                           657                           706                           707
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           657                             1                             3                           657                           658                           707                           708
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           658                             1                             3                           658                           659                           708                           709
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           659                             1                             3                           659                           660                           709                           710
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           660                             1                             3                           660                           661                           710                           711
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           661                             1                             3                           661                           662                           711                           712
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           662                             1                             3                           662                           663                           712                           713
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           663                             1                             3                           663                           664                           713                           714
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           664                             1                             3                           664                           665                           714                           715
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           665                             1                             3                           665                           666                           715                           716
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           666                             1                             3                           666                           667                           716                           717
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           667                             1                             3                           667                           668                           717                           718
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           668                             1                             3                           668                           669                           718                           719
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           669                             1                             3                           669                           670                           719                           720
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           670                             1                             3                           670                           671                           720                           721
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           671                             1                             3                           671                           672                           721                           722
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           672                             1                             3                           672                           673                           722                           723
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           673                             1                             3                           673                           674                           723                           724
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           674                             1                             3                           674                           675                           724                           725
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           675                             1                             3                           675                           676                           725                           726
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           676                             1                             3                           676                           677                           726                           727
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           677                             1                             3                           677                           678                           727                           728
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           678                             1                             3                           678                           679                           728                           729
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           679                             1                             3                           679                           680                           729                           730
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           680                             1                             3                           680                           681                           730                           731
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           681                             1                             3                           681                           682                           731                           732
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           682                             1                             3                           682                           683                           732                           733
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           683                             1                             3                           683                           684                           733                           734
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           684                             1                             3                           684                           685                           734                           735
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           685                             1                             3                           685                           686                           735                           736
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           686                             1                             3                           686                           687                           736                           737
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           687                             1                             3                           687                           688                           737                           738
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           688                             1                             3                           688                           689                           738                           739
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           689                             1                             3                           689                           690                           739                           740
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           690                             1                             3                           690                           691                           740                           741
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           691                             1                             3                           691                           692                           741                           742
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           692                             1                             3                           692                           693                           742                           743
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           693                             1                             3                           693                           694                           743                           744
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           694                             1                             3                           694                           695                           744                           745
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           695                             1                             3                           695                           696                           745                           746
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           696                             1                             3                           696                           697                           746                           747
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           697                             1                             3                           697                           698                           747                           748
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           698                             1                             3                           698                           699                           748                           749
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           699                             1                             3                           699                           700                           749                           750
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           700                             1                             3                           700                           651                           750                           701
  0.5868418943986364322285E-01  0.2087941320775494463691E-01
                           701                             1                             3                           701                           702                           751                           752
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           702                             1                             3                           702                           703                           752                           753
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           703                             1                             3                           703                           704                           753                           754
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           704                             1                             3                           704                           705                           754                           755
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           705                             1                             3                           705                           706                           755                           756
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           706                             1                             3                           706                           707                           756                           757
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           707                             1                             3                           707                           708                           757                           758
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           708                             1                             3                           708                           709                           758                           759
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           709                             1                             3                           709                           710                           759                           760
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           710                             1                             3                           710                           711                           760                           761
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           711                             1                             3                           711                           712                           761                           762
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           712                             1                             3                           712                           713                           762                           763
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           713                             1                             3                           713                           714                           763                           764
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           714                             1                             3                           714                           715                           764                           765
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           715                             1                             3                           715                           716                           765                           766
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           716                             1                             3                           716                           717                           766                           767
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           717                             1                             3                           717                           718                           767                           768
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           718                             1                             3                           718                           719                           768                           769
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           719                             1                             3                           719                           720                           769                           770
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           720                             1                             3                           720                           721                           770                           771
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           721                             1                             3                           721                           722                           771                           772
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           722                             1                             3                           722                           723                           772                           773
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           723                             1                             3                           723                           724                           773                           774
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           724                             1                             3                           724                           725                           774                           775
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           725                             1                             3                           725                           726                           775                           776
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           726                             1                             3                           726                           727                           776                           777
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           727                             1                             3                           727                           728                           777                           778
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           728                             1                             3                           728                           729                           778                           779
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           729                             1                             3                           729                           730                           779                           780
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           730                             1                             3                           730                           731                           780                           781
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           731                             1                             3                           731                           732                           781                           782
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           732                             1                             3                           732                           733                           782                           783
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           733                             1                             3                           733                           734                           783                           784
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
                           734                             1                             3                           734                           735                           784                           785
  0.5865087481908870525871E-01  0.2087844553861300384012E-01
