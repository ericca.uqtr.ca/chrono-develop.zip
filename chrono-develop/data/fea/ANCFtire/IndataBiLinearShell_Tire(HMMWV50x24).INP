                          1000                             0                             0                             0                             0                             0                             0
 -0.5360317224715241413158E-01  0.1437667757714512495326E+00  0.4298720034493597186298E-01  0.5745007321476246209269E-01 -0.8887570259422461482757E+00  0.4547641563776898543381E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1001                             0                             0                             0                             0                             0                             0
  0.2478447035001324042138E-16  0.1500082858941103047812E+00  0.6253888247175992676219E-01  0.1492889648218710989923E-17 -0.9997027456229882202976E+00 -0.2438073817296740330995E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1002                             0                             0                             0                             0                             0                             0
  0.5073001968091572083663E-01  0.1500082858941103047812E+00  0.6573054477975581733062E-01  0.3055716751902672057017E-02 -0.9997027456229883313199E+00 -0.2418848877030004354549E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1003                             0                             0                             0                             0                             0                             0
  0.1006599966468185308743E+00  0.1500082858941103047812E+00  0.7525519728253987628008E-01  0.6063243025231129963715E-02 -0.9997027456229881092753E+00 -0.2361477245022225446291E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1004                             0                             0                             0                             0                             0                             0
  0.1490025053342337868489E+00  0.1500082858941103047812E+00  0.9096263052039144092475E-01  0.8975148334045881734489E-02 -0.9997027456229882202976E+00 -0.2266863706182317694804E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1005                             0                             0                             0                             0                             0                             0
  0.1949951555027458482972E+00  0.1500082858941103047812E+00  0.1126051288879838518930E+00  0.1174551019213898941929E-01 -0.9997027456229883313199E+00 -0.2136500372537175618248E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1006                             0                             0                             0                             0                             0                             0
  0.2379126155845199541705E+00  0.1500082858941103047812E+00  0.1398413772574583768815E+00  0.1433063833807437549572E-01 -0.9997027456229883313199E+00 -0.1972443151733663593839E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1007                             0                             0                             0                             0                             0                             0
  0.2770780515964185175548E+00  0.1500082858941103047812E+00  0.1722418437218821707368E+00  0.1668976375670993758660E-01 -0.9997027456229881092753E+00 -0.1777279324146886080316E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1008                             0                             0                             0                             0                             0                             0
  0.3118738012162365902391E+00  0.1500082858941103047812E+00  0.2092955535700109503949E+00  0.1878568163092058512786E-01 -0.9997027456229883313199E+00 -0.1554086739923105954519E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1009                             0                             0                             0                             0                             0                             0
  0.3417511146864962712222E+00  0.1500082858941103047812E+00  0.2504181476627261870860E+00  0.2058533808378935903161E-01 -0.9997027456229883313199E+00 -0.1306385279444319952313E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1010                             0                             0                             0                             0                             0                             0
  0.3662388089259295820277E+00  0.1500082858941103047812E+00  0.2949610981257388409027E+00  0.2206035145799186206195E-01 -0.9997027456229882202976E+00 -0.1038081342711958364455E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1011                             0                             0                             0                             0                             0                             0
  0.3849506983681412197740E+00  0.1500082858941103047812E+00  0.3422219360215784100809E+00  0.2318745991148664364889E-01 -0.9997027456229882202976E+00 -0.7534062430852933416048E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1012                             0                             0                             0                             0                             0                             0
  0.3975916853386866067765E+00  0.1500082858941103047812E+00  0.3914553297043713575576E+00  0.2394888827066014511114E-01 -0.9997027456229883313199E+00 -0.4568494769420990662956E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1013                             0                             0                             0                             0                             0                             0
  0.4039624139216805298602E+00  0.1500082858941103047812E+00  0.4418848391451363211146E+00  0.2433262835543293159390E-01 -0.9997027456229881092753E+00 -0.1530879216388787928196E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1014                             0                             0                             0                             0                             0                             0
  0.4039624139216805298602E+00  0.1500082858941103047812E+00  0.4927151608548636652074E+00  0.2433262835543293159390E-01 -0.9997027456229881092753E+00  0.1530879216388787928196E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1015                             0                             0                             0                             0                             0                             0
  0.3975916853386866067765E+00  0.1500082858941103047812E+00  0.5431446702956286287645E+00  0.2394888827066014511114E-01 -0.9997027456229883313199E+00  0.4568494769420990662956E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1016                             0                             0                             0                             0                             0                             0
  0.3849506983681412197740E+00  0.1500082858941103047812E+00  0.5923780639784215207300E+00  0.2318745991148664711834E-01 -0.9997027456229882202976E+00  0.7534062430852928211877E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1017                             0                             0                             0                             0                             0                             0
  0.3662388089259295265165E+00  0.1500082858941103047812E+00  0.6396389018742612009305E+00  0.2206035145799185859250E-01 -0.9997027456229881092753E+00  0.1038081342711958711400E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1018                             0                             0                             0                             0                             0                             0
  0.3417511146864961601999E+00  0.1500082858941103047812E+00  0.6841818523372739102584E+00  0.2058533808378935209271E-01 -0.9997027456229881092753E+00  0.1306385279444320819675E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1019                             0                             0                             0                             0                             0                             0
  0.3118738012162365347280E+00  0.1500082858941103047812E+00  0.7253044464299891469494E+00  0.1878568163092058165842E-01 -0.9997027456229881092753E+00  0.1554086739923106301464E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1020                             0                             0                             0                             0                             0                             0
  0.2770780515964186285771E+00  0.1500082858941103047812E+00  0.7623581562781176490518E+00  0.1668976375670994452549E-01 -0.9997027456229881092753E+00  0.1777279324146885733371E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1021                             0                             0                             0                             0                             0                             0
  0.2379126155845199541705E+00  0.1500082858941103047812E+00  0.7947586227425416094405E+00  0.1433063833807437549572E-01 -0.9997027456229883313199E+00  0.1972443151733663593839E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1022                             0                             0                             0                             0                             0                             0
  0.1949951555027457927860E+00  0.1500082858941103047812E+00  0.8219948711120161899402E+00  0.1174551019213898421512E-01 -0.9997027456229882202976E+00  0.2136500372537175965193E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1023                             0                             0                             0                             0                             0                             0
  0.1490025053342337868489E+00  0.1500082858941103047812E+00  0.8436373694796085453973E+00  0.8975148334045881734489E-02 -0.9997027456229882202976E+00  0.2266863706182317694804E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1024                             0                             0                             0                             0                             0                             0
  0.1006599966468187112856E+00  0.1500082858941103047812E+00  0.8593448027174600545308E+00  0.6063243025231141239417E-02 -0.9997027456229881092753E+00  0.2361477245022225099347E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1025                             0                             0                             0                             0                             0                             0
  0.5073001968091581104225E-01  0.1500082858941103047812E+00  0.8688694552202440579691E+00  0.3055716751902677694869E-02 -0.9997027456229881092753E+00  0.2418848877030004007604E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1026                             0                             0                             0                             0                             0                             0
  0.2478447035001324042138E-16  0.1500082858941103047812E+00  0.8720611175282400040487E+00  0.1492889648218710989923E-17 -0.9997027456229882202976E+00  0.2438073817296740330995E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1027                             0                             0                             0                             0                             0                             0
 -0.5073001968091576247000E-01  0.1500082858941103047812E+00  0.8688694552202440579691E+00 -0.3055716751902675092784E-02 -0.9997027456229881092753E+00  0.2418848877030004007604E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1028                             0                             0                             0                             0                             0                             0
 -0.1006599966468184892410E+00  0.1500082858941103047812E+00  0.8593448027174601655531E+00 -0.6063243025231127361629E-02 -0.9997027456229883313199E+00  0.2361477245022225446291E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1029                             0                             0                             0                             0                             0                             0
 -0.1490025053342337313378E+00  0.1500082858941103047812E+00  0.8436373694796085453973E+00 -0.8975148334045878265042E-02 -0.9997027456229881092753E+00  0.2266863706182317694804E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1030                             0                             0                             0                             0                             0                             0
 -0.1949951555027459038083E+00  0.1500082858941103047812E+00  0.8219948711120160789179E+00 -0.1174551019213899115401E-01 -0.9997027456229881092753E+00  0.2136500372537175618248E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1031                             0                             0                             0                             0                             0                             0
 -0.2379126155845197876371E+00  0.1500082858941103047812E+00  0.7947586227425418314851E+00 -0.1433063833807436508738E-01 -0.9997027456229883313199E+00  0.1972443151733664287728E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1032                             0                             0                             0                             0                             0                             0
 -0.2770780515964184620437E+00  0.1500082858941103047812E+00  0.7623581562781178710964E+00 -0.1668976375670993411715E-01 -0.9997027456229882202976E+00  0.1777279324146886774205E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1033                             0                             0                             0                             0                             0                             0
 -0.3118738012162366457503E+00  0.1500082858941103047812E+00  0.7253044464299889249048E+00 -0.1878568163092058859731E-01 -0.9997027456229882202976E+00  0.1554086739923105781047E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1034                             0                             0                             0                             0                             0                             0
 -0.3417511146864963267333E+00  0.1500082858941103047812E+00  0.6841818523372736882138E+00 -0.2058533808378936250105E-01 -0.9997027456229882202976E+00  0.1306385279444319084952E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1035                             0                             0                             0                             0                             0                             0
 -0.3662388089259296930500E+00  0.1500082858941103047812E+00  0.6396389018742609788859E+00 -0.2206035145799186900084E-01 -0.9997027456229882202976E+00  0.1038081342711957150149E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1036                             0                             0                             0                             0                             0                             0
 -0.3849506983681412197740E+00  0.1500082858941103047812E+00  0.5923780639784216317523E+00 -0.2318745991148664364889E-01 -0.9997027456229882202976E+00  0.7534062430852936018133E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1037                             0                             0                             0                             0                             0                             0
 -0.3975916853386866067765E+00  0.1500082858941103047812E+00  0.5431446702956286287645E+00 -0.2394888827066014511114E-01 -0.9997027456229883313199E+00  0.4568494769420988928232E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1038                             0                             0                             0                             0                             0                             0
 -0.4039624139216805298602E+00  0.1500082858941103047812E+00  0.4927151608548635541851E+00 -0.2433262835543293159390E-01 -0.9997027456229881092753E+00  0.1530879216388780121941E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1039                             0                             0                             0                             0                             0                             0
 -0.4039624139216805298602E+00  0.1500082858941103047812E+00  0.4418848391451365431593E+00 -0.2433262835543293159390E-01 -0.9997027456229881092753E+00 -0.1530879216388774267249E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1040                             0                             0                             0                             0                             0                             0
 -0.3975916853386866067765E+00  0.1500082858941103047812E+00  0.3914553297043715240910E+00 -0.2394888827066014511114E-01 -0.9997027456229882202976E+00 -0.4568494769420982856700E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1041                             0                             0                             0                             0                             0                             0
 -0.3849506983681412197740E+00  0.1500082858941103047812E+00  0.3422219360215784655921E+00 -0.2318745991148664711834E-01 -0.9997027456229883313199E+00 -0.7534062430852930813963E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1042                             0                             0                             0                             0                             0                             0
 -0.3662388089259297485611E+00  0.1500082858941103047812E+00  0.2949610981257391184585E+00 -0.2206035145799187247029E-01 -0.9997027456229883313199E+00 -0.1038081342711956629732E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1043                             0                             0                             0                             0                             0                             0
 -0.3417511146864962157110E+00  0.1500082858941103047812E+00  0.2504181476627260760637E+00 -0.2058533808378935556216E-01 -0.9997027456229882202976E+00 -0.1306385279444320472730E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1044                             0                             0                             0                             0                             0                             0
 -0.3118738012162367567726E+00  0.1500082858941103047812E+00  0.2092955535700110614172E+00 -0.1878568163092059206676E-01 -0.9997027456229883313199E+00 -0.1554086739923105260630E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1045                             0                             0                             0                             0                             0                             0
 -0.2770780515964186840883E+00  0.1500082858941103047812E+00  0.1722418437218822817592E+00 -0.1668976375670994799494E-01 -0.9997027456229883313199E+00 -0.1777279324146885733371E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1046                             0                             0                             0                             0                             0                             0
 -0.2379126155845200096817E+00  0.1500082858941103047812E+00  0.1398413772574583768815E+00 -0.1433063833807437896517E-01 -0.9997027456229881092753E+00 -0.1972443151733663246894E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1047                             0                             0                             0                             0                             0                             0
 -0.1949951555027461536085E+00  0.1500082858941103047812E+00  0.1126051288879840184265E+00 -0.1174551019213900676652E-01 -0.9997027456229882202976E+00 -0.2136500372537174577414E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1048                             0                             0                             0                             0                             0                             0
 -0.1490025053342336758266E+00  0.1500082858941103047812E+00  0.9096263052039138541360E-01 -0.8975148334045874795595E-02 -0.9997027456229881092753E+00 -0.2266863706182318041749E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1049                             0                             0                             0                             0                             0                             0
 -0.1006599966468187529189E+00  0.1500082858941103047812E+00  0.7525519728253993179123E-01 -0.6063243025231143841502E-02 -0.9997027456229882202976E+00 -0.2361477245022225099347E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1050                             0                             0                             0                             0                             0                             0
 -0.5073001968091585267562E-01  0.1500082858941103047812E+00  0.6573054477975587284178E-01 -0.3055716751902680296954E-02 -0.9997027456229881092753E+00 -0.2418848877030004007604E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1051                             0                             0                             0                             0                             0                             0
  0.2267905928450650471371E-16  0.1454899278495849213044E+00  0.9692285451941656804209E-01  0.1339179490475880993808E-16 -0.9757911121022321276897E+00 -0.2187046079585183155913E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1052                             0                             0                             0                             0                             0                             0
  0.4642056528139826276913E-01  0.1454899278495849213044E+00  0.9984338893782207513539E-01  0.2741095571085457038851E-01 -0.9757911121022322387120E+00 -0.2169800568008653784968E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1053                             0                             0                             0                             0                             0                             0
  0.9210905051800727383338E-01  0.1454899278495849213044E+00  0.1085589336206176369615E+00  0.5438962427563771157013E-01 -0.9757911121022320166674E+00 -0.2118336005298596391722E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1054                             0                             0                             0                             0                             0                             0
  0.1363449210046677184671E+00  0.1454899278495849213044E+00  0.1229320392217415069958E+00  0.8051053597480743728720E-01 -0.9757911121022321276897E+00 -0.2033464018352388602562E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1055                             0                             0                             0                             0                             0                             0
  0.1784305506385766015853E+00  0.1454899278495849213044E+00  0.1427360332797868447408E+00  0.1053617484269914472694E+00 -0.9757911121022322387120E+00 -0.1916523089104239241376E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1056                             0                             0                             0                             0                             0                             0
  0.2177022238996707548253E+00  0.1454899278495849213044E+00  0.1676585949781257411928E+00  0.1285513431664241090768E+00 -0.9757911121022322387120E+00 -0.1769357445865517020067E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1057                             0                             0                             0                             0                             0                             0
  0.2535406030408622335415E+00  0.1454899278495849213044E+00  0.1973066806307586240621E+00  0.1497136064312721559499E+00 -0.9757911121022320166674E+00 -0.1594287978742590095038E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1058                             0                             0                             0                             0                             0                             0
  0.2853804954142846184162E+00  0.1454899278495849213044E+00  0.2312127222160356432301E+00  0.1685147966881256342830E+00 -0.9757911121022321276897E+00 -0.1394075637813417534172E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1059                             0                             0                             0                             0                             0                             0
  0.3127197668969790567139E+00  0.1454899278495849213044E+00  0.2688420012036694117796E+00  0.1846584079353472962470E+00 -0.9757911121022322387120E+00 -0.1171877891295508150593E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1060                             0                             0                             0                             0                             0                             0
  0.3351272608459744395404E+00  0.1454899278495849213044E+00  0.3096010813853833365528E+00  0.1978898457798425047915E+00 -0.9757911121022321276897E+00 -0.9311989303859487254744E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1061                             0                             0                             0                             0                             0                             0
  0.3522495976961069197309E+00  0.1454899278495849213044E+00  0.3528471677184174537523E+00  0.2080004425427257330750E+00 -0.9757911121022320166674E+00 -0.6758344060729253033326E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1062                             0                             0                             0                             0                             0                             0
  0.3638167479668618642386E+00  0.1454899278495849213044E+00  0.3978982435873400502757E+00  0.2148307480732686569613E+00 -0.9757911121022322387120E+00 -0.4098115694522270341382E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1063                             0                             0                             0                             0                             0                             0
  0.3696462907885886828296E+00  0.1454899278495849213044E+00  0.4440438266134900668902E+00  0.2182730443730277469783E+00 -0.9757911121022321276897E+00 -0.1373257595717018719750E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1064                             0                             0                             0                             0                             0                             0
  0.3696462907885886828296E+00  0.1454899278495849213044E+00  0.4905561733865099194318E+00  0.2182730443730277469783E+00 -0.9757911121022321276897E+00  0.1373257595717018719750E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1065                             0                             0                             0                             0                             0                             0
  0.3638167479668618642386E+00  0.1454899278495849213044E+00  0.5367017564126599360463E+00  0.2148307480732686569613E+00 -0.9757911121022322387120E+00  0.4098115694522270341382E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1066                             0                             0                             0                             0                             0                             0
  0.3522495976961069752420E+00  0.1454899278495849213044E+00  0.5817528322815824770586E+00  0.2080004425427257608305E+00 -0.9757911121022321276897E+00  0.6758344060729247482211E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1067                             0                             0                             0                             0                             0                             0
  0.3351272608459743840292E+00  0.1454899278495849213044E+00  0.6249989186146167607916E+00  0.1978898457798424770360E+00 -0.9757911121022320166674E+00  0.9311989303859490030302E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1068                             0                             0                             0                             0                             0                             0
  0.3127197668969789456916E+00  0.1454899278495849213044E+00  0.6657579987963306855647E+00  0.1846584079353472129803E+00 -0.9757911121022320166674E+00  0.1171877891295508844482E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1069                             0                             0                             0                             0                             0                             0
  0.2853804954142845629050E+00  0.1454899278495849213044E+00  0.7033872777839643708475E+00  0.1685147966881256065275E+00 -0.9757911121022320166674E+00  0.1394075637813417811728E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1070                             0                             0                             0                             0                             0                             0
  0.2535406030408623445638E+00  0.1454899278495849213044E+00  0.7372933193692412512377E+00  0.1497136064312722114611E+00 -0.9757911121022320166674E+00  0.1594287978742589817482E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1071                             0                             0                             0                             0                             0                             0
  0.2177022238996707548253E+00  0.1454899278495849213044E+00  0.7669414050218742451293E+00  0.1285513431664241090768E+00 -0.9757911121022322387120E+00  0.1769357445865517020067E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1072                             0                             0                             0                             0                             0                             0
  0.1784305506385765183186E+00  0.1454899278495849213044E+00  0.7918639667202131970924E+00  0.1053617484269914056361E+00 -0.9757911121022321276897E+00  0.1916523089104239518932E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1073                             0                             0                             0                             0                             0                             0
  0.1363449210046677184671E+00  0.1454899278495849213044E+00  0.8116679607782584238151E+00  0.8051053597480743728720E-01 -0.9757911121022321276897E+00  0.2033464018352388602562E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1074                             0                             0                             0                             0                             0                             0
  0.9210905051800744036683E-01  0.1454899278495849213044E+00  0.8260410663793822383383E+00  0.5438962427563780871465E-01 -0.9757911121022320166674E+00  0.2118336005298596114166E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1075                             0                             0                             0                             0                             0                             0
  0.4642056528139833909696E-01  0.1454899278495849213044E+00  0.8347566110621779111867E+00  0.2741095571085461896077E-01 -0.9757911121022320166674E+00  0.2169800568008653507412E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1076                             0                             0                             0                             0                             0                             0
  0.2267905928450650471371E-16  0.1454899278495849213044E+00  0.8376771454805833627688E+00  0.1339179490475880993808E-16 -0.9757911121022321276897E+00  0.2187046079585183155913E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1077                             0                             0                             0                             0                             0                             0
 -0.4642056528139829746360E-01  0.1454899278495849213044E+00  0.8347566110621779111867E+00 -0.2741095571085459467464E-01 -0.9757911121022320166674E+00  0.2169800568008653507412E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1078                             0                             0                             0                             0                             0                             0
 -0.9210905051800724607780E-01  0.1454899278495849213044E+00  0.8260410663793824603829E+00 -0.5438962427563769075345E-01 -0.9757911121022321276897E+00  0.2118336005298596669277E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1079                             0                             0                             0                             0                             0                             0
 -0.1363449210046676629560E+00  0.1454899278495849213044E+00  0.8116679607782584238151E+00 -0.8051053597480742340942E-01 -0.9757911121022320166674E+00  0.2033464018352388602562E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1080                             0                             0                             0                             0                             0                             0
 -0.1784305506385766293409E+00  0.1454899278495849213044E+00  0.7918639667202130860701E+00 -0.1053617484269914750250E+00 -0.9757911121022321276897E+00  0.1916523089104238963820E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1081                             0                             0                             0                             0                             0                             0
 -0.2177022238996705882919E+00  0.1454899278495849213044E+00  0.7669414050218743561516E+00 -0.1285513431664240258101E+00 -0.9757911121022322387120E+00  0.1769357445865517852734E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1082                             0                             0                             0                             0                             0                             0
 -0.2535406030408621780303E+00  0.1454899278495849213044E+00  0.7372933193692414732823E+00 -0.1497136064312721004388E+00 -0.9757911121022321276897E+00  0.1594287978742590650150E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1083                             0                             0                             0                             0                             0                             0
 -0.2853804954142846184162E+00  0.1454899278495849213044E+00  0.7033872777839642598252E+00 -0.1685147966881256620386E+00 -0.9757911121022321276897E+00  0.1394075637813417534172E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1084                             0                             0                             0                             0                             0                             0
 -0.3127197668969791122251E+00  0.1454899278495849213044E+00  0.6657579987963304635201E+00 -0.1846584079353473240026E+00 -0.9757911121022320166674E+00  0.1171877891295507317926E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1085                             0                             0                             0                             0                             0                             0
 -0.3351272608459744950515E+00  0.1454899278495849213044E+00  0.6249989186146164277247E+00 -0.1978898457798425325471E+00 -0.9757911121022321276897E+00  0.9311989303859476152514E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1086                             0                             0                             0                             0                             0                             0
 -0.3522495976961069197309E+00  0.1454899278495849213044E+00  0.5817528322815825880809E+00 -0.2080004425427257330750E+00 -0.9757911121022321276897E+00  0.6758344060729255808884E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1087                             0                             0                             0                             0                             0                             0
 -0.3638167479668618642386E+00  0.1454899278495849213044E+00  0.5367017564126598250240E+00 -0.2148307480732686569613E+00 -0.9757911121022322387120E+00  0.4098115694522268259714E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1088                             0                             0                             0                             0                             0                             0
 -0.3696462907885886828296E+00  0.1454899278495849213044E+00  0.4905561733865098084095E+00 -0.2182730443730277469783E+00 -0.9757911121022320166674E+00  0.1373257595717011780856E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1089                             0                             0                             0                             0                             0                             0
 -0.3696462907885886828296E+00  0.1454899278495849213044E+00  0.4440438266134902334237E+00 -0.2182730443730277469783E+00 -0.9757911121022320166674E+00 -0.1373257595717006576685E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1090                             0                             0                             0                             0                             0                             0
 -0.3638167479668618642386E+00  0.1454899278495849213044E+00  0.3978982435873402168092E+00 -0.2148307480732686569613E+00 -0.9757911121022321276897E+00 -0.4098115694522262708599E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1091                             0                             0                             0                             0                             0                             0
 -0.3522495976961069752420E+00  0.1454899278495849213044E+00  0.3528471677184175092634E+00 -0.2080004425427257608305E+00 -0.9757911121022321276897E+00 -0.6758344060729250257769E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1092                             0                             0                             0                             0                             0                             0
 -0.3351272608459745505627E+00  0.1454899278495849213044E+00  0.3096010813853836141085E+00 -0.1978898457798425603027E+00 -0.9757911121022320166674E+00 -0.9311989303859470601399E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1093                             0                             0                             0                             0                             0                             0
 -0.3127197668969790012028E+00  0.1454899278495849213044E+00  0.2688420012036693562685E+00 -0.1846584079353472407359E+00 -0.9757911121022321276897E+00 -0.1171877891295508566927E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1094                             0                             0                             0                             0                             0                             0
 -0.2853804954142847294385E+00  0.1454899278495849213044E+00  0.2312127222160357820080E+00 -0.1685147966881257175498E+00 -0.9757911121022322387120E+00 -0.1394075637813416979061E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1095                             0                             0                             0                             0                             0                             0
 -0.2535406030408624000749E+00  0.1454899278495849213044E+00  0.1973066806307587350844E+00 -0.1497136064312722392167E+00 -0.9757911121022322387120E+00 -0.1594287978742589817482E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1096                             0                             0                             0                             0                             0                             0
 -0.2177022238996707825809E+00  0.1454899278495849213044E+00  0.1676585949781257967039E+00 -0.1285513431664241368324E+00 -0.9757911121022321276897E+00 -0.1769357445865516742511E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1097                             0                             0                             0                             0                             0                             0
 -0.1784305506385768513855E+00  0.1454899278495849213044E+00  0.1427360332797870112742E+00 -0.1053617484269915999251E+00 -0.9757911121022321276897E+00 -0.1916523089104238408709E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1098                             0                             0                             0                             0                             0                             0
 -0.1363449210046676074448E+00  0.1454899278495849213044E+00  0.1229320392217414514846E+00 -0.8051053597480738177605E-01 -0.9757911121022320166674E+00 -0.2033464018352388602562E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1099                             0                             0                             0                             0                             0                             0
 -0.9210905051800748200019E-01  0.1454899278495849213044E+00  0.1085589336206176924726E+00 -0.5438962427563783647022E-01 -0.9757911121022320166674E+00 -0.2118336005298596114166E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1100                             0                             0                             0                             0                             0                             0
 -0.4642056528139838073033E-01  0.1454899278495849213044E+00  0.9984338893782207513539E-01 -0.2741095571085464324690E-01 -0.9757911121022321276897E+00 -0.2169800568008653507412E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1101                             0                             0                             0                             0                             0                             0
  0.2059584207234561445540E-16  0.1354477585648095894211E+00  0.1309443734359124200672E+00  0.2049810739450918309433E-16 -0.9423036020307958837705E+00 -0.3347594981472333808270E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1102                             0                             0                             0                             0                             0                             0
  0.4215653830482468666929E-01  0.1354477585648095894211E+00  0.1335966380159261945870E+00  0.4195649036915648222301E-01 -0.9423036020307959947928E+00 -0.3321198195165269706486E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1103                             0                             0                             0                             0                             0                             0
  0.8364824281748695078420E-01  0.1354477585648095894211E+00  0.1415116039591546859278E+00  0.8325130182159887204385E-01 -0.9423036020307957727482E+00 -0.3242424129332814319859E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1104                             0                             0                             0                             0                             0                             0
  0.1238207645718793631362E+00  0.1354477585648095894211E+00  0.1545644475245016580267E+00  0.1232331905123976167893E+00 -0.9423036020307958837705E+00 -0.3112515098050492312609E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1105                             0                             0                             0                             0                             0                             0
  0.1620405589020336989403E+00  0.1354477585648095894211E+00  0.1725493175715508420431E+00  0.1612716181728760522773E+00 -0.9423036020307959947928E+00 -0.2933519844345519600459E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1106                             0                             0                             0                             0                             0                             0
  0.1977048768199650974342E+00  0.1354477585648095894211E+00  0.1951825819560196184632E+00  0.1967666960757732674825E+00 -0.9423036020307959947928E+00 -0.2708261230295405663782E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1107                             0                             0                             0                             0                             0                             0
  0.2302512707272768854860E+00  0.1354477585648095894211E+00  0.2221073005781082077004E+00  0.2291586456388288173258E+00 -0.9423036020307958837705E+00 -0.2440291718806692766730E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1108                             0                             0                             0                             0                             0                             0
  0.2591664645497775421035E+00  0.1354477585648095894211E+00  0.2528988545410989496887E+00  0.2579366264674206044027E+00 -0.9423036020307959947928E+00 -0.2133837349152785667350E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1109                             0                             0                             0                             0                             0                             0
  0.2839944484077865927141E+00  0.1354477585648095894211E+00  0.2870716426450127256587E+00  0.2826467926127492757971E+00 -0.9423036020307959947928E+00 -0.1793731089810093881631E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1110                             0                             0                             0                             0                             0                             0
  0.3043436701643445485566E+00  0.1354477585648095894211E+00  0.3240867396076166917496E+00  0.3028994499935651063538E+00 -0.9423036020307959947928E+00 -0.1425336619658082726314E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1111                             0                             0                             0                             0                             0                             0
  0.3198932104363147455039E+00  0.1354477585648095894211E+00  0.3633603952380634050101E+00  0.3183752021046216684752E+00 -0.9423036020307957727482E+00 -0.1034463739559238343313E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1112                             0                             0                             0                             0                             0                             0
  0.3303978436847631039441E+00  0.1354477585648095894211E+00  0.4042732405261161843235E+00  0.3288299870903614308126E+00 -0.9423036020307958837705E+00 -0.6272767483288604895009E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1113                             0                             0                             0                             0                             0                             0
  0.3356919055681977237526E+00  0.1354477585648095894211E+00  0.4461800554614331892900E+00  0.3340989267461733636111E+00 -0.9423036020307957727482E+00 -0.2101972280603702988855E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1114                             0                             0                             0                             0                             0                             0
  0.3356919055681977237526E+00  0.1354477585648095894211E+00  0.4884199445385667970321E+00  0.3340989267461733636111E+00 -0.9423036020307957727482E+00  0.2101972280603702988855E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1115                             0                             0                             0                             0                             0                             0
  0.3303978436847631039441E+00  0.1354477585648095894211E+00  0.5303267594738838575097E+00  0.3288299870903614308126E+00 -0.9423036020307958837705E+00  0.6272767483288604895009E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1116                             0                             0                             0                             0                             0                             0
  0.3198932104363147455039E+00  0.1354477585648095894211E+00  0.5712396047619364702896E+00  0.3183752021046217239864E+00 -0.9423036020307958837705E+00  0.1034463739559237510646E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1117                             0                             0                             0                             0                             0                             0
  0.3043436701643444930454E+00  0.1354477585648095894211E+00  0.6105132603923834055948E+00  0.3028994499935651063538E+00 -0.9423036020307958837705E+00  0.1425336619658083281426E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1118                             0                             0                             0                             0                             0                             0
  0.2839944484077864816918E+00  0.1354477585648095894211E+00  0.6475283573549873716857E+00  0.2826467926127491647748E+00 -0.9423036020307957727482E+00  0.1793731089810094991854E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1119                             0                             0                             0                             0                             0                             0
  0.2591664645497774865923E+00  0.1354477585648095894211E+00  0.6817011454589010366334E+00  0.2579366264674205488916E+00 -0.9423036020307957727482E+00  0.2133837349152786222461E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1120                             0                             0                             0                             0                             0                             0
  0.2302512707272769687528E+00  0.1354477585648095894211E+00  0.7124926994218917508661E+00  0.2291586456388288728370E+00 -0.9423036020307957727482E+00  0.2440291718806691934063E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1121                             0                             0                             0                             0                             0                             0
  0.1977048768199650974342E+00  0.1354477585648095894211E+00  0.7394174180439803123477E+00  0.1967666960757732674825E+00 -0.9423036020307959947928E+00  0.2708261230295405663782E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1122                             0                             0                             0                             0                             0                             0
  0.1620405589020336434292E+00  0.1354477585648095894211E+00  0.7620506824284491997901E+00  0.1612716181728759967662E+00 -0.9423036020307959947928E+00  0.2933519844345520155571E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1123                             0                             0                             0                             0                             0                             0
  0.1238207645718793631362E+00  0.1354477585648095894211E+00  0.7800355524754982727842E+00  0.1232331905123976167893E+00 -0.9423036020307958837705E+00  0.3112515098050492312609E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1124                             0                             0                             0                             0                             0                             0
  0.8364824281748710343987E-01  0.1354477585648095894211E+00  0.7930883960408452448831E+00  0.8325130182159901082173E-01 -0.9423036020307957727482E+00  0.3242424129332813764748E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1125                             0                             0                             0                             0                             0                             0
  0.4215653830482476299713E-01  0.1354477585648095894211E+00  0.8010033619840737362239E+00  0.4195649036915655161195E-01 -0.9423036020307958837705E+00  0.3321198195165269151374E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1126                             0                             0                             0                             0                             0                             0
  0.2059584207234561445540E-16  0.1354477585648095894211E+00  0.8036556265640875107437E+00  0.2049810739450918309433E-16 -0.9423036020307958837705E+00  0.3347594981472333808270E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1127                             0                             0                             0                             0                             0                             0
 -0.4215653830482472830266E-01  0.1354477585648095894211E+00  0.8010033619840737362239E+00 -0.4195649036915651691748E-01 -0.9423036020307957727482E+00  0.3321198195165269151374E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1128                             0                             0                             0                             0                             0                             0
 -0.8364824281748692302862E-01  0.1354477585648095894211E+00  0.7930883960408452448831E+00 -0.8325130182159883041049E-01 -0.9423036020307958837705E+00  0.3242424129332814874971E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1129                             0                             0                             0                             0                             0                             0
 -0.1238207645718793215028E+00  0.1354477585648095894211E+00  0.7800355524754982727842E+00 -0.1232331905123975751559E+00 -0.9423036020307957727482E+00  0.3112515098050492312609E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1130                             0                             0                             0                             0                             0                             0
 -0.1620405589020337544515E+00  0.1354477585648095894211E+00  0.7620506824284490887678E+00 -0.1612716181728760800329E+00 -0.9423036020307958837705E+00  0.2933519844345519600459E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1131                             0                             0                             0                             0                             0                             0
 -0.1977048768199649309008E+00  0.1354477585648095894211E+00  0.7394174180439805343923E+00 -0.1967666960757731287046E+00 -0.9423036020307959947928E+00  0.2708261230295406774005E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1132                             0                             0                             0                             0                             0                             0
 -0.2302512707272768022193E+00  0.1354477585648095894211E+00  0.7124926994218918618884E+00 -0.2291586456388287340591E+00 -0.9423036020307958837705E+00  0.2440291718806693599397E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1133                             0                             0                             0                             0                             0                             0
 -0.2591664645497775421035E+00  0.1354477585648095894211E+00  0.6817011454589010366334E+00 -0.2579366264674206599139E+00 -0.9423036020307958837705E+00  0.2133837349152785389794E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1134                             0                             0                             0                             0                             0                             0
 -0.2839944484077865927141E+00  0.1354477585648095894211E+00  0.6475283573549871496411E+00 -0.2826467926127492757971E+00 -0.9423036020307957727482E+00  0.1793731089810092771408E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1135                             0                             0                             0                             0                             0                             0
 -0.3043436701643446040677E+00  0.1354477585648095894211E+00  0.6105132603923831835502E+00 -0.3028994499935652173761E+00 -0.9423036020307959947928E+00  0.1425336619658081060980E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1136                             0                             0                             0                             0                             0                             0
 -0.3198932104363147455039E+00  0.1354477585648095894211E+00  0.5712396047619365813119E+00 -0.3183752021046216684752E+00 -0.9423036020307957727482E+00  0.1034463739559238620869E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1137                             0                             0                             0                             0                             0                             0
 -0.3303978436847631039441E+00  0.1354477585648095894211E+00  0.5303267594738837464874E+00 -0.3288299870903614308126E+00 -0.9423036020307958837705E+00  0.6272767483288602119451E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1138                             0                             0                             0                             0                             0                             0
 -0.3356919055681977237526E+00  0.1354477585648095894211E+00  0.4884199445385666860098E+00 -0.3340989267461733636111E+00 -0.9423036020307957727482E+00  0.2101972280603692233569E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1139                             0                             0                             0                             0                             0                             0
 -0.3356919055681977237526E+00  0.1354477585648095894211E+00  0.4461800554614333558234E+00 -0.3340989267461733636111E+00 -0.9423036020307957727482E+00 -0.2101972280603684253841E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1140                             0                             0                             0                             0                             0                             0
 -0.3303978436847631039441E+00  0.1354477585648095894211E+00  0.4042732405261162953458E+00 -0.3288299870903614308126E+00 -0.9423036020307957727482E+00 -0.6272767483288593792778E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1141                             0                             0                             0                             0                             0                             0
 -0.3198932104363147455039E+00  0.1354477585648095894211E+00  0.3633603952380634605213E+00 -0.3183752021046217239864E+00 -0.9423036020307958837705E+00 -0.1034463739559237926979E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1142                             0                             0                             0                             0                             0                             0
 -0.3043436701643446595789E+00  0.1354477585648095894211E+00  0.3240867396076169137942E+00 -0.3028994499935652173761E+00 -0.9423036020307958837705E+00 -0.1425336619658080228312E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1143                             0                             0                             0                             0                             0                             0
 -0.2839944484077864816918E+00  0.1354477585648095894211E+00  0.2870716426450126146364E+00 -0.2826467926127491647748E+00 -0.9423036020307957727482E+00 -0.1793731089810094714299E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1144                             0                             0                             0                             0                             0                             0
 -0.2591664645497776531258E+00  0.1354477585648095894211E+00  0.2528988545410990607110E+00 -0.2579366264674207154250E+00 -0.9423036020307957727482E+00 -0.2133837349152784557127E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1145                             0                             0                             0                             0                             0                             0
 -0.2302512707272769965083E+00  0.1354477585648095894211E+00  0.2221073005781082632115E+00 -0.2291586456388289283481E+00 -0.9423036020307959947928E+00 -0.2440291718806691934063E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1146                             0                             0                             0                             0                             0                             0
 -0.1977048768199651251898E+00  0.1354477585648095894211E+00  0.1951825819560196739744E+00 -0.1967666960757732952381E+00 -0.9423036020307957727482E+00 -0.2708261230295405108670E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1147                             0                             0                             0                             0                             0                             0
 -0.1620405589020339487405E+00  0.1354477585648095894211E+00  0.1725493175715510085766E+00 -0.1612716181728762743219E+00 -0.9423036020307958837705E+00 -0.2933519844345518490236E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1148                             0                             0                             0                             0                             0                             0
 -0.1238207645718792659917E+00  0.1354477585648095894211E+00  0.1545644475245016580267E+00 -0.1232331905123975196448E+00 -0.9423036020307957727482E+00 -0.3112515098050492867721E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1149                             0                             0                             0                             0                             0                             0
 -0.8364824281748714507323E-01  0.1354477585648095894211E+00  0.1415116039591547414389E+00 -0.8325130182159905245509E-01 -0.9423036020307958837705E+00 -0.3242424129332813764748E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1150                             0                             0                             0                             0                             0                             0
 -0.4215653830482480463049E-01  0.1354477585648095894211E+00  0.1335966380159262500982E+00 -0.4195649036915659324531E-01 -0.9423036020307958837705E+00 -0.3321198195165269151374E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1151                             0                             0                             0                             0                             0                             0
  0.1851223917906933645146E-16  0.1226772314110201045345E+00  0.1649721910030176874606E+00  0.2025286470206510068544E-16 -0.9437168746105094596643E+00 -0.3307543810373069770314E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1152                             0                             0                             0                             0                             0                             0
  0.3789172189800314727304E-01  0.1226772314110201045345E+00  0.1673561360778983986286E+00  0.4145451609096568318380E-01 -0.9437168746105095706866E+00 -0.3281462839512828133515E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1153                             0                             0                             0                             0                             0                             0
  0.7518586870625729168260E-01  0.1226772314110201045345E+00  0.1744703750646098838750E+00  0.8225526969944924049472E-01 -0.9437168746105094596643E+00 -0.3203631239422585208487E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1154                             0                             0                             0                             0                             0                             0
  0.1112942894511529112744E+00  0.1226772314110201045345E+00  0.1862027121644913019161E+00  0.1217588085678562026537E+00 -0.9437168746105094596643E+00 -0.3075276460930109756475E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1155                             0                             0                             0                             0                             0                             0
  0.1456475327674178477100E+00  0.1226772314110201045345E+00  0.2023681214129190997220E+00  0.1593421382899613547579E+00 -0.9437168746105094596643E+00 -0.2898422735567655061928E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1156                             0                             0                             0                             0                             0                             0
  0.1777038274863218803024E+00  0.1226772314110201045345E+00  0.2227116646492981744121E+00  0.1944125473048542718235E+00 -0.9437168746105095706866E+00 -0.2675859152231482296358E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1157                             0                             0                             0                             0                             0                             0
  0.2069576266906455741523E+00  0.1226772314110201045345E+00  0.2469125120441471310517E+00  0.2264169543123232264392E+00 -0.9437168746105093486420E+00 -0.2411095671583842192653E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1158                             0                             0                             0                             0                             0                             0
  0.2329475804915642767057E+00  0.1226772314110201045345E+00  0.2745890017771637214850E+00  0.2548506306953544076066E+00 -0.9437168746105093486420E+00 -0.2108307771876585523518E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1159                             0                             0                             0                             0                             0                             0
  0.2552638117919915350384E+00  0.1226772314110201045345E+00  0.3053046590721247288691E+00  0.2792651603919324432290E+00 -0.9437168746105095706866E+00 -0.1772270599164819937510E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1160                             0                             0                             0                             0                             0                             0
  0.2735543802932492440938E+00  0.1226772314110201045345E+00  0.3385750796648442917380E+00  0.2992755116842091833718E+00 -0.9437168746105095706866E+00 -0.1408283660401086490044E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1161                             0                             0                             0                             0                             0                             0
  0.2875308328038165828211E+00  0.1226772314110201045345E+00  0.3738755691477893550179E+00  0.3145661093787009421341E+00 -0.9437168746105093486420E+00 -0.1022087247044946994867E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1162                             0                             0                             0                             0                             0                             0
  0.2969727523184738648965E+00  0.1226772314110201045345E+00  0.4106494177143235613237E+00  0.3248958116156053788082E+00 -0.9437168746105094596643E+00 -0.6197719072375826310228E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1163                             0                             0                             0                             0                             0                             0
  0.3017312341261456087871E+00  0.1226772314110201045345E+00  0.4483166798049204038179E+00  0.3301017128199814076872E+00 -0.9437168746105094596643E+00 -0.2076823942192900993020E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1164                             0                             0                             0                             0                             0                             0
  0.3017312341261456087871E+00  0.1226772314110201045345E+00  0.4862833201950795825041E+00  0.3301017128199814076872E+00 -0.9437168746105094596643E+00  0.2076823942192900993020E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1165                             0                             0                             0                             0                             0                             0
  0.2969727523184738648965E+00  0.1226772314110201045345E+00  0.5239505822856763694872E+00  0.3248958116156053788082E+00 -0.9437168746105094596643E+00  0.6197719072375826310228E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1166                             0                             0                             0                             0                             0                             0
  0.2875308328038165828211E+00  0.1226772314110201045345E+00  0.5607244308522105757930E+00  0.3145661093787009976452E+00 -0.9437168746105094596643E+00  0.1022087247044946300978E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1167                             0                             0                             0                             0                             0                             0
  0.2735543802932492440938E+00  0.1226772314110201045345E+00  0.5960249203351557500952E+00  0.2992755116842091278606E+00 -0.9437168746105094596643E+00  0.1408283660401087045155E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1168                             0                             0                             0                             0                             0                             0
  0.2552638117919914795273E+00  0.1226772314110201045345E+00  0.6292953409278754239864E+00  0.2792651603919323322067E+00 -0.9437168746105093486420E+00  0.1772270599164821047733E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1169                             0                             0                             0                             0                             0                             0
  0.2329475804915642489501E+00  0.1226772314110201045345E+00  0.6600109982228362648371E+00  0.2548506306953543520954E+00 -0.9437168746105093486420E+00  0.2108307771876585801074E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1170                             0                             0                             0                             0                             0                             0
  0.2069576266906456574191E+00  0.1226772314110201045345E+00  0.6876874879558527720036E+00  0.2264169543123232819504E+00 -0.9437168746105094596643E+00  0.2411095671583841359986E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1171                             0                             0                             0                             0                             0                             0
  0.1777038274863218803024E+00  0.1226772314110201045345E+00  0.7118883353507018396655E+00  0.1944125473048542718235E+00 -0.9437168746105095706866E+00  0.2675859152231482296358E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1172                             0                             0                             0                             0                             0                             0
  0.1456475327674177921988E+00  0.1226772314110201045345E+00  0.7322318785870809421112E+00  0.1593421382899612992468E+00 -0.9437168746105095706866E+00  0.2898422735567655617039E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1173                             0                             0                             0                             0                             0                             0
  0.1112942894511529112744E+00  0.1226772314110201045345E+00  0.7483972878355087399171E+00  0.1217588085678562026537E+00 -0.9437168746105094596643E+00  0.3075276460930109756475E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1174                             0                             0                             0                             0                             0                             0
