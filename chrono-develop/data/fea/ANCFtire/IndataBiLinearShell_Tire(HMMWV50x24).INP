                          1102                             1                             1                          1102                          1103                          1152                          1153
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1103                             1                             1                          1103                          1104                          1153                          1154
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1104                             1                             1                          1104                          1105                          1154                          1155
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1105                             1                             1                          1105                          1106                          1155                          1156
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1106                             1                             1                          1106                          1107                          1156                          1157
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1107                             1                             1                          1107                          1108                          1157                          1158
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1108                             1                             1                          1108                          1109                          1158                          1159
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1109                             1                             1                          1109                          1110                          1159                          1160
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1110                             1                             1                          1110                          1111                          1160                          1161
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1111                             1                             1                          1111                          1112                          1161                          1162
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1112                             1                             1                          1112                          1113                          1162                          1163
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1113                             1                             1                          1113                          1114                          1163                          1164
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1114                             1                             1                          1114                          1115                          1164                          1165
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1115                             1                             1                          1115                          1116                          1165                          1166
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1116                             1                             1                          1116                          1117                          1166                          1167
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1117                             1                             1                          1117                          1118                          1167                          1168
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1118                             1                             1                          1118                          1119                          1168                          1169
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1119                             1                             1                          1119                          1120                          1169                          1170
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1120                             1                             1                          1120                          1121                          1170                          1171
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1121                             1                             1                          1121                          1122                          1171                          1172
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1122                             1                             1                          1122                          1123                          1172                          1173
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1123                             1                             1                          1123                          1124                          1173                          1174
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1124                             1                             1                          1124                          1125                          1174                          1175
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1125                             1                             1                          1125                          1126                          1175                          1176
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1126                             1                             1                          1126                          1127                          1176                          1177
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1127                             1                             1                          1127                          1128                          1177                          1178
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1128                             1                             1                          1128                          1129                          1178                          1179
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1129                             1                             1                          1129                          1130                          1179                          1180
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1130                             1                             1                          1130                          1131                          1180                          1181
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1131                             1                             1                          1131                          1132                          1181                          1182
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1132                             1                             1                          1132                          1133                          1182                          1183
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1133                             1                             1                          1133                          1134                          1183                          1184
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1134                             1                             1                          1134                          1135                          1184                          1185
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1135                             1                             1                          1135                          1136                          1185                          1186
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1136                             1                             1                          1136                          1137                          1186                          1187
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1137                             1                             1                          1137                          1138                          1187                          1188
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1138                             1                             1                          1138                          1139                          1188                          1189
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1139                             1                             1                          1139                          1140                          1189                          1190
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1140                             1                             1                          1140                          1141                          1190                          1191
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1141                             1                             1                          1141                          1142                          1191                          1192
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1142                             1                             1                          1142                          1143                          1192                          1193
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1143                             1                             1                          1143                          1144                          1193                          1194
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1144                             1                             1                          1144                          1145                          1194                          1195
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1145                             1                             1                          1145                          1146                          1195                          1196
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1146                             1                             1                          1146                          1147                          1196                          1197
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1147                             1                             1                          1147                          1148                          1197                          1198
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1148                             1                             1                          1148                          1149                          1198                          1199
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1149                             1                             1                          1149                          1150                          1199                          1200
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1150                             1                             1                          1150                          1101                          1200                          1151
  0.4012966378256294097682E-01  0.3634527111146472477810E-01
                          1151                             1                             1                          1151                          1152                          1201                          1202
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1152                             1                             1                          1152                          1153                          1202                          1203
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1153                             1                             1                          1153                          1154                          1203                          1204
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1154                             1                             1                          1154                          1155                          1204                          1205
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1155                             1                             1                          1155                          1156                          1205                          1206
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1156                             1                             1                          1156                          1157                          1206                          1207
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1157                             1                             1                          1157                          1158                          1207                          1208
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1158                             1                             1                          1158                          1159                          1208                          1209
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1159                             1                             1                          1159                          1160                          1209                          1210
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1160                             1                             1                          1160                          1161                          1210                          1211
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1161                             1                             1                          1161                          1162                          1211                          1212
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1162                             1                             1                          1162                          1163                          1212                          1213
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1163                             1                             1                          1163                          1164                          1213                          1214
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1164                             1                             1                          1164                          1165                          1214                          1215
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1165                             1                             1                          1165                          1166                          1215                          1216
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1166                             1                             1                          1166                          1167                          1216                          1217
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1167                             1                             1                          1167                          1168                          1217                          1218
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1168                             1                             1                          1168                          1169                          1218                          1219
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1169                             1                             1                          1169                          1170                          1219                          1220
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1170                             1                             1                          1170                          1171                          1220                          1221
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1171                             1                             1                          1171                          1172                          1221                          1222
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1172                             1                             1                          1172                          1173                          1222                          1223
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1173                             1                             1                          1173                          1174                          1223                          1224
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1174                             1                             1                          1174                          1175                          1224                          1225
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1175                             1                             1                          1175                          1176                          1225                          1226
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1176                             1                             1                          1176                          1177                          1226                          1227
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1177                             1                             1                          1177                          1178                          1227                          1228
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1178                             1                             1                          1178                          1179                          1228                          1229
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1179                             1                             1                          1179                          1180                          1229                          1230
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1180                             1                             1                          1180                          1181                          1230                          1231
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1181                             1                             1                          1181                          1182                          1231                          1232
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1182                             1                             1                          1182                          1183                          1232                          1233
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1183                             1                             1                          1183                          1184                          1233                          1234
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1184                             1                             1                          1184                          1185                          1234                          1235
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1185                             1                             1                          1185                          1186                          1235                          1236
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1186                             1                             1                          1186                          1187                          1236                          1237
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1187                             1                             1                          1187                          1188                          1237                          1238
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1188                             1                             1                          1188                          1189                          1238                          1239
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1189                             1                             1                          1189                          1190                          1239                          1240
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1190                             1                             1                          1190                          1191                          1240                          1241
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1191                             1                             1                          1191                          1192                          1241                          1242
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1192                             1                             1                          1192                          1193                          1242                          1243
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1193                             1                             1                          1193                          1194                          1243                          1244
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1194                             1                             1                          1194                          1195                          1244                          1245
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1195                             1                             1                          1195                          1196                          1245                          1246
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1196                             1                             1                          1196                          1197                          1246                          1247
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1197                             1                             1                          1197                          1198                          1247                          1248
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1198                             1                             1                          1198                          1199                          1248                          1249
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1199                             1                             1                          1199                          1200                          1249                          1250
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
                          1200                             1                             1                          1200                          1151                          1250                          1201
  0.3585360265357918213569E-01  0.3488311435742893346079E-01
 NODES [#ofNode, Constrain/ Coordinate / Velocity]
                             1                             0                             0                             0                             0                             0                             0
  0.1642863681056174140932E-16 -0.1150000000000000049960E+00  0.1990000000000000102141E+00  0.3548016624496210321019E-17  0.9983198634690081396670E+00 -0.5794350872376390765295E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                             2                             0                             0                             0                             0                             0                             0
  0.3362690656530283039860E-01 -0.1150000000000000049960E+00  0.2011156256373256012715E+00  0.7262247312410803276594E-02  0.9983198634690082506893E+00 -0.5748660685058987196427E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                             3                             0                             0                             0                             0                             0                             0
  0.6672349672633051675952E-01 -0.1150000000000000049960E+00  0.2074291378691883180885E+00  0.1440996464644862286308E-01  0.9983198634690080286447E+00 -0.5612310684654765735591E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                             4                             0                             0                             0                             0                             0                             0
  0.9876781748529912807744E-01 -0.1150000000000000049960E+00  0.2178409688361821749947E+00  0.2133042822991633100105E-01  0.9983198634690081396670E+00 -0.5387451192121644333310E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                             5                             0                             0                             0                             0                             0                             0
  0.1292545107614902211157E+00 -0.1150000000000000049960E+00  0.2321869177442314191584E+00  0.2791449821801805786237E-01  0.9983198634690081396670E+00 -0.5077628375981419611707E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                             6                             0                             0                             0                             0                             0                             0
  0.1577027831900705279189E+00 -0.1150000000000000049960E+00  0.2502407404092016340869E+00  0.3405833989390868316027E-01  0.9983198634690082506893E+00 -0.4687728327123802385401E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                             7                             0                             0                             0                             0                             0                             0
  0.1836639885206671485296E+00 -0.1150000000000000049960E+00  0.2717177172628352788131E+00  0.3966506120420630610024E-01  0.9983198634690081396670E+00 -0.4223900002234276529478E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                             8                             0                             0                             0                             0                             0                             0
  0.2067287030367442324241E+00 -0.1150000000000000049960E+00  0.2962791435504266157608E+00  0.4464624080455456556216E-01  0.9983198634690081396670E+00 -0.3693458251073959003330E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                             9                             0                             0                             0                             0                             0                             0
  0.2265331824121906700853E+00 -0.1150000000000000049960E+00  0.3235376709071352552272E+00  0.4892332251704349654897E-01  0.9983198634690082506893E+00 -0.3104768456929194245242E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            10                             0                             0                             0                             0                             0                             0
  0.2427650981766330262612E+00 -0.1150000000000000049960E+00  0.3530634160730909965054E+00  0.5242885420806239066271E-01  0.9983198634690082506893E+00 -0.2467114609519880166766E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            11                             0                             0                             0                             0                             0                             0
  0.2551684633219896691791E+00 -0.1150000000000000049960E+00  0.3843907404092016255603E+00  0.5510755154874073802329E-01  0.9983198634690080286447E+00 -0.1790552890935606655809E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            12                             0                             0                             0                             0                             0                             0
  0.2635476693705071649099E+00 -0.1150000000000000049960E+00  0.4170255932966500656001E+00  0.5691716988183984082816E-01  0.9983198634690083617116E+00 -0.1085753083636828604519E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            13                             0                             0                             0                             0                             0                             0
  0.2677705712373052437947E+00 -0.1150000000000000049960E+00  0.4504533036102851828453E+00  0.5782917044523310651227E-01  0.9983198634690081396670E+00 -0.3638303016116442231698E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            14                             0                             0                             0                             0                             0                             0
  0.2677705712373052437947E+00 -0.1150000000000000049960E+00  0.4841466963897148034768E+00  0.5782917044523310651227E-01  0.9983198634690081396670E+00  0.3638303016116442231698E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            15                             0                             0                             0                             0                             0                             0
  0.2635476693705071649099E+00 -0.1150000000000000049960E+00  0.5175744067033498652108E+00  0.5691716988183984082816E-01  0.9983198634690083617116E+00  0.1085753083636828604519E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            16                             0                             0                             0                             0                             0                             0
  0.2551684633219897246903E+00 -0.1150000000000000049960E+00  0.5502092595907983607617E+00  0.5510755154874074496218E-01  0.9983198634690081396670E+00  0.1790552890935605268030E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            17                             0                             0                             0                             0                             0                             0
  0.2427650981766329985057E+00 -0.1150000000000000049960E+00  0.5815365839269089898167E+00  0.5242885420806238372382E-01  0.9983198634690081396670E+00  0.2467114609519881207600E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            18                             0                             0                             0                             0                             0                             0
  0.2265331824121905590630E+00 -0.1150000000000000049960E+00  0.6110623290928648421172E+00  0.4892332251704348267118E-01  0.9983198634690080286447E+00  0.3104768456929195979965E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            19                             0                             0                             0                             0                             0                             0
  0.2067287030367442046686E+00 -0.1150000000000000049960E+00  0.6383208564495734815836E+00  0.4464624080455455862326E-01  0.9983198634690080286447E+00  0.3693458251073959697219E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            20                             0                             0                             0                             0                             0                             0
  0.1836639885206672040407E+00 -0.1150000000000000049960E+00  0.6628822827371646519978E+00  0.3966506120420631997803E-01  0.9983198634690080286447E+00  0.4223900002234275141699E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            21                             0                             0                             0                             0                             0                             0
  0.1577027831900705279189E+00 -0.1150000000000000049960E+00  0.6843592595907983522352E+00  0.3405833989390868316027E-01  0.9983198634690082506893E+00  0.4687728327123802385401E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            22                             0                             0                             0                             0                             0                             0
  0.1292545107614901656046E+00 -0.1150000000000000049960E+00  0.7024130822557685949192E+00  0.2791449821801804745403E-01  0.9983198634690081396670E+00  0.5077628375981420305596E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            23                             0                             0                             0                             0                             0                             0
  0.9876781748529912807744E-01 -0.1150000000000000049960E+00  0.7167590311638177835718E+00  0.2133042822991633100105E-01  0.9983198634690081396670E+00  0.5387451192121644333310E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            24                             0                             0                             0                             0                             0                             0
  0.6672349672633064165961E-01 -0.1150000000000000049960E+00  0.7271708621308117237447E+00  0.1440996464644864888394E-01  0.9983198634690080286447E+00  0.5612310684654765041701E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            25                             0                             0                             0                             0                             0                             0
  0.3362690656530289284865E-01 -0.1150000000000000049960E+00  0.7334843743626744405617E+00  0.7262247312410816287020E-02  0.9983198634690081396670E+00  0.5748660685058986502538E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            26                             0                             0                             0                             0                             0                             0
  0.1642863681056174140932E-16 -0.1150000000000000049960E+00  0.7356000000000000316192E+00  0.3548016624496210321019E-17  0.9983198634690081396670E+00  0.5794350872376390765295E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            27                             0                             0                             0                             0                             0                             0
 -0.3362690656530285815418E-01 -0.1150000000000000049960E+00  0.7334843743626744405617E+00 -0.7262247312410809348127E-02  0.9983198634690081396670E+00  0.5748660685058986502538E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            28                             0                             0                             0                             0                             0                             0
 -0.6672349672633048900394E-01 -0.1150000000000000049960E+00  0.7271708621308117237447E+00 -0.1440996464644861592419E-01  0.9983198634690082506893E+00  0.5612310684654766429480E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            29                             0                             0                             0                             0                             0                             0
 -0.9876781748529910032186E-01 -0.1150000000000000049960E+00  0.7167590311638177835718E+00 -0.2133042822991632406215E-01  0.9983198634690080286447E+00  0.5387451192121644333310E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            30                             0                             0                             0                             0                             0                             0
 -0.1292545107614902488713E+00 -0.1150000000000000049960E+00  0.7024130822557685949192E+00 -0.2791449821801806133181E-01  0.9983198634690081396670E+00  0.5077628375981418917817E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            31                             0                             0                             0                             0                             0                             0
 -0.1577027831900704168966E+00 -0.1150000000000000049960E+00  0.6843592595907984632575E+00 -0.3405833989390866234359E-01  0.9983198634690082506893E+00  0.4687728327123804467069E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            32                             0                             0                             0                             0                             0                             0
 -0.1836639885206670930184E+00 -0.1150000000000000049960E+00  0.6628822827371647630201E+00 -0.3966506120420629222245E-01  0.9983198634690081396670E+00  0.4223900002234277223367E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            33                             0                             0                             0                             0                             0                             0
 -0.2067287030367442601797E+00 -0.1150000000000000049960E+00  0.6383208564495733705613E+00 -0.4464624080455456556216E-01  0.9983198634690080286447E+00  0.3693458251073959003330E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            34                             0                             0                             0                             0                             0                             0
 -0.2265331824121906978409E+00 -0.1150000000000000049960E+00  0.6110623290928647310949E+00 -0.4892332251704350348787E-01  0.9983198634690081396670E+00  0.3104768456929192163574E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            35                             0                             0                             0                             0                             0                             0
 -0.2427650981766331095280E+00 -0.1150000000000000049960E+00  0.5815365839269088787944E+00 -0.5242885420806240454050E-01  0.9983198634690081396670E+00  0.2467114609519877044264E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            36                             0                             0                             0                             0                             0                             0
 -0.2551684633219896691791E+00 -0.1150000000000000049960E+00  0.5502092595907983607617E+00 -0.5510755154874073802329E-01  0.9983198634690081396670E+00  0.1790552890935607349698E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            37                             0                             0                             0                             0                             0                             0
 -0.2635476693705071649099E+00 -0.1150000000000000049960E+00  0.5175744067033498652108E+00 -0.5691716988183984082816E-01  0.9983198634690082506893E+00  0.1085753083636828084102E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            38                             0                             0                             0                             0                             0                             0
 -0.2677705712373052437947E+00 -0.1150000000000000049960E+00  0.4841466963897146924545E+00 -0.5782917044523310651227E-01  0.9983198634690081396670E+00  0.3638303016116424017101E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            39                             0                             0                             0                             0                             0                             0
 -0.2677705712373052437947E+00 -0.1150000000000000049960E+00  0.4504533036102853493787E+00 -0.5782917044523310651227E-01  0.9983198634690081396670E+00 -0.3638303016116410139313E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            40                             0                             0                             0                             0                             0                             0
 -0.2635476693705071649099E+00 -0.1150000000000000049960E+00  0.4170255932966501766224E+00 -0.5691716988183984082816E-01  0.9983198634690082506893E+00 -0.1085753083636826696323E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            41                             0                             0                             0                             0                             0                             0
 -0.2551684633219897246903E+00 -0.1150000000000000049960E+00  0.3843907404092016255603E+00 -0.5510755154874074496218E-01  0.9983198634690082506893E+00 -0.1790552890935605961920E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            42                             0                             0                             0                             0                             0                             0
 -0.2427650981766331372835E+00 -0.1150000000000000049960E+00  0.3530634160730912185500E+00 -0.5242885420806240454050E-01  0.9983198634690081396670E+00 -0.2467114609519876003429E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            43                             0                             0                             0                             0                             0                             0
 -0.2265331824121905868186E+00 -0.1150000000000000049960E+00  0.3235376709071351442049E+00 -0.4892332251704348961008E-01  0.9983198634690082506893E+00 -0.3104768456929195286076E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            44                             0                             0                             0                             0                             0                             0
 -0.2067287030367443434464E+00 -0.1150000000000000049960E+00  0.2962791435504266712719E+00 -0.4464624080455457943994E-01  0.9983198634690081396670E+00 -0.3693458251073957615551E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            45                             0                             0                             0                             0                             0                             0
 -0.1836639885206672317963E+00 -0.1150000000000000049960E+00  0.2717177172628353343242E+00 -0.3966506120420632691692E-01  0.9983198634690082506893E+00 -0.4223900002234275141699E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            46                             0                             0                             0                             0                             0                             0
 -0.1577027831900705556745E+00 -0.1150000000000000049960E+00  0.2502407404092016340869E+00 -0.3405833989390869009917E-01  0.9983198634690080286447E+00 -0.4687728327123801691512E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            47                             0                             0                             0                             0                             0                             0
 -0.1292545107614904154048E+00 -0.1150000000000000049960E+00  0.2321869177442315301807E+00 -0.2791449821801809949573E-01  0.9983198634690080286447E+00 -0.5077628375981416836149E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            48                             0                             0                             0                             0                             0                             0
 -0.9876781748529904481071E-01 -0.1150000000000000049960E+00  0.2178409688361821472391E+00 -0.2133042822991631365381E-01  0.9983198634690081396670E+00 -0.5387451192121645027200E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            49                             0                             0                             0                             0                             0                             0
 -0.6672349672633066941518E-01 -0.1150000000000000049960E+00  0.2074291378691883180885E+00 -0.1440996464644865408811E-01  0.9983198634690081396670E+00 -0.5612310684654765041701E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            50                             0                             0                             0                             0                             0                             0
 -0.3362690656530292060422E-01 -0.1150000000000000049960E+00  0.2011156256373256012715E+00 -0.7262247312410822358553E-02  0.9983198634690081396670E+00 -0.5748660685058986502538E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            51                             0                             0                             0                             0                             0                             0
  0.1851223700959694400072E-16 -0.1226772188959260462271E+00  0.1649722264331905940971E+00  0.2025286161845667300435E-16  0.9437168922604080023575E+00 -0.3307543306781596803567E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            52                             0                             0                             0                             0                             0                             0
  0.3789171745742501290488E-01 -0.1226772188959260462271E+00  0.1673561712286937841476E+00  0.4145450977929091007645E-01  0.9437168922604081133798E+00 -0.3281462339892324275858E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            53                             0                             0                             0                             0                             0                             0
  0.7518585989513158762687E-01 -0.1226772188959260462271E+00  0.1744704093816787371374E+00  0.8225525717563858529857E-01  0.9437168922604080023575E+00 -0.3203630751652364883064E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            54                             0                             0                             0                             0                             0                             0
  0.1112942764084363517219E+00 -0.1226772188959260462271E+00  0.1862027451066329830631E+00  0.1217587900294176267435E+00  0.9437168922604080023575E+00 -0.3075275992702599658912E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            55                             0                             0                             0                             0                             0                             0
  0.1456475156988018826443E+00 -0.1226772188959260462271E+00  0.2023681524606162906998E+00  0.1593421140292571314134E+00  0.9437168922604080023575E+00 -0.2898422294267083421104E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            56                             0                             0                             0                             0                             0                             0
  0.1777038066609887556613E+00 -0.1226772188959260462271E+00  0.2227116933129101583599E+00  0.1944125177044901675583E+00  0.9437168922604080023575E+00 -0.2675858744817422030238E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            57                             0                             0                             0                             0                             0                             0
  0.2069576024370232691929E+00 -0.1226772188959260462271E+00  0.2469125378716316432381E+00  0.2264169198391146886618E+00  0.9437168922604080023575E+00 -0.2411095304481457313184E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            58                             0                             0                             0                             0                             0                             0
  0.2329475531921468556273E+00 -0.1226772188959260462271E+00  0.2745890243612059133937E+00  0.2548505918929645508442E+00  0.9437168922604080023575E+00 -0.2108307450875299693394E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            59                             0                             0                             0                             0                             0                             0
  0.2552637818773071387568E+00 -0.1226772188959260462271E+00  0.3053046780565606965752E+00  0.2792651178722981297753E+00  0.9437168922604080023575E+00 -0.1772270329327015059295E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            60                             0                             0                             0                             0                             0                             0
  0.2735543482350703548001E+00 -0.1226772188959260462271E+00  0.3385750947502781937892E+00  0.2992754661178903541341E+00  0.9437168922604080023575E+00 -0.1408283445982266013363E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            61                             0                             0                             0                             0                             0                             0
  0.2875307991077197256047E+00 -0.1226772188959260462271E+00  0.3738755800963148856475E+00  0.3145660614843057700796E+00  0.9437168922604078913352E+00 -0.1022087091426623628454E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            62                             0                             0                             0                             0                             0                             0
  0.2969727175158667353827E+00 -0.1226772188959260462271E+00  0.4106494243532759491622E+00  0.3248957621484570568171E+00  0.9437168922604081133798E+00 -0.6197718128739503756774E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            63                             0                             0                             0                             0                             0                             0
  0.3017311987658860550354E+00 -0.1226772188959260462271E+00  0.4483166820295994003942E+00  0.3301016625602063991884E+00  0.9437168922604080023575E+00 -0.2076823625985198609745E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            64                             0                             0                             0                             0                             0                             0
  0.3017311987658860550354E+00 -0.1226772188959260462271E+00  0.4862833179704005859278E+00  0.3301016625602063991884E+00  0.9437168922604080023575E+00  0.2076823625985198609745E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            65                             0                             0                             0                             0                             0                             0
  0.2969727175158667353827E+00 -0.1226772188959260462271E+00  0.5239505756467239816487E+00  0.3248957621484570568171E+00  0.9437168922604081133798E+00  0.6197718128739503756774E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            66                             0                             0                             0                             0                             0                             0
  0.2875307991077197811158E+00 -0.1226772188959260462271E+00  0.5607244199036850451634E+00  0.3145660614843058255907E+00  0.9437168922604080023575E+00  0.1022087091426622934565E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            67                             0                             0                             0                             0                             0                             0
  0.2735543482350702992889E+00 -0.1226772188959260462271E+00  0.5960249052497218480440E+00  0.2992754661178903541341E+00  0.9437168922604080023575E+00  0.1408283445982266568475E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            68                             0                             0                             0                             0                             0                             0
  0.2552637818773070832457E+00 -0.1226772188959260462271E+00  0.6292953219434394007692E+00  0.2792651178722980187530E+00  0.9437168922604077803129E+00  0.1772270329327016169518E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            69                             0                             0                             0                             0                             0                             0
  0.2329475531921468278718E+00 -0.1226772188959260462271E+00  0.6600109756387940729283E+00  0.2548505918929644953330E+00  0.9437168922604078913352E+00  0.2108307450875299970949E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            70                             0                             0                             0                             0                             0                             0
  0.2069576024370233247041E+00 -0.1226772188959260462271E+00  0.6876874621283682875728E+00  0.2264169198391147441729E+00  0.9437168922604080023575E+00  0.2411095304481456758072E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            71                             0                             0                             0                             0                             0                             0
  0.1777038066609887556613E+00 -0.1226772188959260462271E+00  0.7118883066870898002065E+00  0.1944125177044901675583E+00  0.9437168922604080023575E+00  0.2675858744817422030238E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            72                             0                             0                             0                             0                             0                             0
  0.1456475156988018271331E+00 -0.1226772188959260462271E+00  0.7322318475393836401111E+00  0.1593421140292570759023E+00  0.9437168922604081133798E+00  0.2898422294267083421104E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            73                             0                             0                             0                             0                             0                             0
  0.1112942764084363517219E+00 -0.1226772188959260462271E+00  0.7483972548933670587701E+00  0.1217587900294176267435E+00  0.9437168922604080023575E+00  0.3075275992702599658912E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            74                             0                             0                             0                             0                             0                             0
  0.7518585989513171252696E-01 -0.1226772188959260462271E+00  0.7601295906183211936735E+00  0.8225525717563872407645E-01  0.9437168922604080023575E+00  0.3203630751652364327953E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            75                             0                             0                             0                             0                             0                             0
  0.3789171745742508229382E-01 -0.1226772188959260462271E+00  0.7672438287713061466633E+00  0.4145450977929098640429E-01  0.9437168922604078913352E+00  0.3281462339892324275858E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            76                             0                             0                             0                             0                             0                             0
  0.1851223700959694400072E-16 -0.1226772188959260462271E+00  0.7696277735668093367138E+00  0.2025286161845667300435E-16  0.9437168922604080023575E+00  0.3307543306781596803567E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            77                             0                             0                             0                             0                             0                             0
 -0.3789171745742504759935E-01 -0.1226772188959260462271E+00  0.7672438287713061466633E+00 -0.4145450977929095170982E-01  0.9437168922604078913352E+00  0.3281462339892324275858E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            78                             0                             0                             0                             0                             0                             0
 -0.7518585989513154599351E-01 -0.1226772188959260462271E+00  0.7601295906183211936735E+00 -0.8225525717563854366521E-01  0.9437168922604081133798E+00  0.3203630751652364883064E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            79                             0                             0                             0                             0                             0                             0
 -0.1112942764084363239663E+00 -0.1226772188959260462271E+00  0.7483972548933670587701E+00 -0.1217587900294175989879E+00  0.9437168922604080023575E+00  0.3075275992702599658912E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            80                             0                             0                             0                             0                             0                             0
 -0.1456475156988019103999E+00 -0.1226772188959260462271E+00  0.7322318475393836401111E+00 -0.1593421140292571591690E+00  0.9437168922604078913352E+00  0.2898422294267082865993E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            81                             0                             0                             0                             0                             0                             0
 -0.1777038066609886168834E+00 -0.1226772188959260462271E+00  0.7118883066870899112288E+00 -0.1944125177044900287804E+00  0.9437168922604081133798E+00  0.2675858744817423140461E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            82                             0                             0                             0                             0                             0                             0
 -0.2069576024370231859262E+00 -0.1226772188959260462271E+00  0.6876874621283683985951E+00 -0.2264169198391146053950E+00  0.9437168922604080023575E+00  0.2411095304481458145851E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            83                             0                             0                             0                             0                             0                             0
 -0.2329475531921468833829E+00 -0.1226772188959260462271E+00  0.6600109756387940729283E+00 -0.2548505918929645508442E+00  0.9437168922604080023575E+00  0.2108307450875299138282E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            84                             0                             0                             0                             0                             0                             0
 -0.2552637818773071942680E+00 -0.1226772188959260462271E+00  0.6292953219434391787246E+00 -0.2792651178722981297753E+00  0.9437168922604080023575E+00  0.1772270329327013949072E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            85                             0                             0                             0                             0                             0                             0
 -0.2735543482350704103112E+00 -0.1226772188959260462271E+00  0.5960249052497216259994E+00 -0.2992754661178904651564E+00  0.9437168922604080023575E+00  0.1408283445982264348029E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            86                             0                             0                             0                             0                             0                             0
 -0.2875307991077197256047E+00 -0.1226772188959260462271E+00  0.5607244199036851561857E+00 -0.3145660614843057700796E+00  0.9437168922604080023575E+00  0.1022087091426623906010E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            87                             0                             0                             0                             0                             0                             0
 -0.2969727175158667353827E+00 -0.1226772188959260462271E+00  0.5239505756467239816487E+00 -0.3248957621484570568171E+00  0.9437168922604081133798E+00  0.6197718128739500981217E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            88                             0                             0                             0                             0                             0                             0
 -0.3017311987658860550354E+00 -0.1226772188959260462271E+00  0.4862833179704004749055E+00 -0.3301016625602063991884E+00  0.9437168922604080023575E+00  0.2076823625985188201404E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            89                             0                             0                             0                             0                             0                             0
 -0.3017311987658860550354E+00 -0.1226772188959260462271E+00  0.4483166820295995669277E+00 -0.3301016625602063991884E+00  0.9437168922604078913352E+00 -0.2076823625985180221676E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            90                             0                             0                             0                             0                             0                             0
 -0.2969727175158667353827E+00 -0.1226772188959260462271E+00  0.4106494243532760601845E+00 -0.3248957621484570568171E+00  0.9437168922604080023575E+00 -0.6197718128739492654544E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            91                             0                             0                             0                             0                             0                             0
 -0.2875307991077197811158E+00 -0.1226772188959260462271E+00  0.3738755800963149411587E+00 -0.3145660614843058255907E+00  0.9437168922604081133798E+00 -0.1022087091426623212120E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            92                             0                             0                             0                             0                             0                             0
 -0.2735543482350704103112E+00 -0.1226772188959260462271E+00  0.3385750947502784158338E+00 -0.2992754661178904651564E+00  0.9437168922604080023575E+00 -0.1408283445982263515361E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            93                             0                             0                             0                             0                             0                             0
 -0.2552637818773070832457E+00 -0.1226772188959260462271E+00  0.3053046780565606965752E+00 -0.2792651178722980187530E+00  0.9437168922604080023575E+00 -0.1772270329327015614407E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            94                             0                             0                             0                             0                             0                             0
 -0.2329475531921469388941E+00 -0.1226772188959260462271E+00  0.2745890243612060244160E+00 -0.2548505918929646618665E+00  0.9437168922604080023575E+00 -0.2108307450875298583171E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            95                             0                             0                             0                             0                             0                             0
 -0.2069576024370233524596E+00 -0.1226772188959260462271E+00  0.2469125378716316987493E+00 -0.2264169198391147996841E+00  0.9437168922604081133798E+00 -0.2411095304481456758072E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            96                             0                             0                             0                             0                             0                             0
 -0.1777038066609887834169E+00 -0.1226772188959260462271E+00  0.2227116933129102138711E+00 -0.1944125177044902230694E+00  0.9437168922604080023575E+00 -0.2675858744817422030238E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            97                             0                             0                             0                             0                             0                             0
 -0.1456475156988021046889E+00 -0.1226772188959260462271E+00  0.2023681524606164572333E+00 -0.1593421140292573534580E+00  0.9437168922604078913352E+00 -0.2898422294267081755770E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            98                             0                             0                             0                             0                             0                             0
 -0.1112942764084362684551E+00 -0.1226772188959260462271E+00  0.1862027451066329275520E+00 -0.1217587900294175434768E+00  0.9437168922604080023575E+00 -0.3075275992702599658912E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            99                             0                             0                             0                             0                             0                             0
 -0.7518585989513175416032E-01 -0.1226772188959260462271E+00  0.1744704093816787926485E+00 -0.8225525717563876570981E-01  0.9437168922604080023575E+00 -0.3203630751652364327953E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           100                             0                             0                             0                             0                             0                             0
 -0.3789171745742511698829E-01 -0.1226772188959260462271E+00  0.1673561712286938396588E+00 -0.4145450977929102109876E-01  0.9437168922604080023575E+00 -0.3281462339892324275858E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           101                             0                             0                             0                             0                             0                             0
  0.2059584268922830958386E-16 -0.1354477621473950677000E+00  0.1309443633614534863163E+00  0.2049810573507234680540E-16  0.9423036116584815324870E+00 -0.3347594710465732203986E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           102                             0                             0                             0                             0                             0                             0
  0.4215653956748920128117E-01 -0.1354477621473950677000E+00  0.1335966280209073819840E+00  0.4195648697254310971472E-01  0.9423036116584816435093E+00 -0.3321197926295635927119E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           103                             0                             0                             0                             0                             0                             0
  0.8364824532290300596049E-01 -0.1354477621473950677000E+00  0.1415115942012034055963E+00  0.8325129508193875038646E-01  0.9423036116584814214647E+00 -0.3242423866840383195331E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           104                             0                             0                             0                             0                             0                             0
  0.1238207682805350512423E+00 -0.1354477621473950677000E+00  0.1545644381575066450552E+00  0.1232331805359792170629E+00  0.9423036116584815324870E+00 -0.3112514846074926899711E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           105                             0                             0                             0                             0                             0                             0
  0.1620405637554413191825E+00 -0.1354477621473950677000E+00  0.1725493087432351524413E+00  0.1612716051170334508047E+00  0.9423036116584815324870E+00 -0.2933519606860624517886E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           106                             0                             0                             0                             0                             0                             0
  0.1977048827415834875154E+00 -0.1354477621473950677000E+00  0.1951825738056111592122E+00  0.1967666801464048875747E+00  0.9423036116584815324870E+00 -0.2708261011046458888174E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           107                             0                             0                             0                             0                             0                             0
  0.2302512776237185809780E+00 -0.1354477621473950677000E+00  0.2221072932341436878545E+00  0.2291586270871503183688E+00  0.9423036116584815324870E+00 -0.2440291521251382322877E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           108                             0                             0                             0                             0                             0                             0
  0.2591664723122815150447E+00 -0.1354477621473950677000E+00  0.2528988481193971127325E+00  0.2579366055860030648716E+00  0.9423036116584814214647E+00 -0.2133837176406676583440E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           109                             0                             0                             0                             0                             0                             0
  0.2839944569139336016939E+00 -0.1354477621473950677000E+00  0.2870716372468476995650E+00  0.2826467697309050786103E+00  0.9423036116584816435093E+00 -0.1793730944597495269299E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           110                             0                             0                             0                             0                             0                             0
  0.3043436792799875112436E+00 -0.1354477621473950677000E+00  0.3240867353181207111135E+00  0.3028994254721546486309E+00  0.9423036116584815324870E+00 -0.1425336504269083814922E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           111                             0                             0                             0                             0                             0                             0
  0.3198932200176945461756E+00 -0.1354477621473950677000E+00  0.3633603921248844126346E+00  0.3183751763303622195345E+00  0.9423036116584815324870E+00 -0.1034463655813592786181E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           112                             0                             0                             0                             0                             0                             0
  0.3303978535807756689024E+00 -0.1354477621473950677000E+00  0.4042732386383507958705E+00  0.3288299604697284550525E+00  0.9423036116584816435093E+00 -0.6272766975472872374997E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           113                             0                             0                             0                             0                             0                             0
  0.3356919156227770595358E+00 -0.1354477621473950677000E+00  0.4461800548288527012986E+00  0.3340988996989901482770E+00  0.9423036116584815324870E+00 -0.2101972110437249838255E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           114                             0                             0                             0                             0                             0                             0
  0.3356919156227770595358E+00 -0.1354477621473950677000E+00  0.4884199451711472850235E+00  0.3340988996989901482770E+00  0.9423036116584815324870E+00  0.2101972110437249838255E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           115                             0                             0                             0                             0                             0                             0
  0.3303978535807756689024E+00 -0.1354477621473950677000E+00  0.5303267613616491349404E+00  0.3288299604697284550525E+00  0.9423036116584816435093E+00  0.6272766975472872374997E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           116                             0                             0                             0                             0                             0                             0
  0.3198932200176946016867E+00 -0.1354477621473950677000E+00  0.5712396078751155181763E+00  0.3183751763303622750456E+00  0.9423036116584815324870E+00  0.1034463655813592092292E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           117                             0                             0                             0                             0                             0                             0
  0.3043436792799875112436E+00 -0.1354477621473950677000E+00  0.6105132646818793862309E+00  0.3028994254721546486309E+00  0.9423036116584815324870E+00  0.1425336504269084370033E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           118                             0                             0                             0                             0                             0                             0
  0.2839944569139334906716E+00 -0.1354477621473950677000E+00  0.6475283627531523977794E+00  0.2826467697309049675880E+00  0.9423036116584814214647E+00  0.1793730944597496379522E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           119                             0                             0                             0                             0                             0                             0
  0.2591664723122815150447E+00 -0.1354477621473950677000E+00  0.6817011518806028735895E+00  0.2579366055860030093605E+00  0.9423036116584814214647E+00  0.2133837176406676860996E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           120                             0                             0                             0                             0                             0                             0
  0.2302512776237186642447E+00 -0.1354477621473950677000E+00  0.7124927067658561874453E+00  0.2291586270871504016355E+00  0.9423036116584814214647E+00  0.2440291521251381767765E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           121                             0                             0                             0                             0                             0                             0
  0.1977048827415834875154E+00 -0.1354477621473950677000E+00  0.7394174261943888826210E+00  0.1967666801464048875747E+00  0.9423036116584815324870E+00  0.2708261011046458888174E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           122                             0                             0                             0                             0                             0                             0
  0.1620405637554412636714E+00 -0.1354477621473950677000E+00  0.7620506912567648338808E+00  0.1612716051170333952935E+00  0.9423036116584816435093E+00  0.2933519606860625072997E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           123                             0                             0                             0                             0                             0                             0
  0.1238207682805350512423E+00 -0.1354477621473950677000E+00  0.7800355618424933412669E+00  0.1232331805359792170629E+00  0.9423036116584815324870E+00  0.3112514846074926899711E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           124                             0                             0                             0                             0                             0                             0
  0.8364824532290315861616E-01 -0.1354477621473950677000E+00  0.7930884057987965807257E+00  0.8325129508193890304213E-01  0.9423036116584814214647E+00  0.3242423866840383195331E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           125                             0                             0                             0                             0                             0                             0
  0.4215653956748927760900E-01 -0.1354477621473950677000E+00  0.8010033719790925488269E+00  0.4195648697254318604255E-01  0.9423036116584815324870E+00  0.3321197926295635372007E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           126                             0                             0                             0                             0                             0                             0
  0.2059584268922830958386E-16 -0.1354477621473950677000E+00  0.8036556366385465555169E+00  0.2049810573507234680540E-16  0.9423036116584815324870E+00  0.3347594710465732203986E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           127                             0                             0                             0                             0                             0                             0
 -0.4215653956748924291453E-01 -0.1354477621473950677000E+00  0.8010033719790925488269E+00 -0.4195648697254314440919E-01  0.9423036116584815324870E+00  0.3321197926295635372007E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           128                             0                             0                             0                             0                             0                             0
