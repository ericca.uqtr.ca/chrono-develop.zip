  0.7518586870625741658269E-01  0.1226772314110201045345E+00  0.7601296249353900469359E+00  0.8225526969944939315038E-01 -0.9437168746105093486420E+00  0.3203631239422585208487E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1175                             0                             0                             0                             0                             0                             0
  0.3789172189800321666198E-01  0.1226772314110201045345E+00  0.7672438639221015321823E+00  0.4145451609096575951163E-01 -0.9437168746105093486420E+00  0.3281462839512827578403E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1176                             0                             0                             0                             0                             0                             0
  0.1851223917906933645146E-16  0.1226772314110201045345E+00  0.7696278089969823543726E+00  0.2025286470206510068544E-16 -0.9437168746105094596643E+00  0.3307543810373069770314E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1177                             0                             0                             0                             0                             0                             0
 -0.3789172189800318196751E-01  0.1226772314110201045345E+00  0.7672438639221015321823E+00 -0.4145451609096571787827E-01 -0.9437168746105093486420E+00  0.3281462839512827578403E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1178                             0                             0                             0                             0                             0                             0
 -0.7518586870625725004924E-01  0.1226772314110201045345E+00  0.7601296249353901579582E+00 -0.8225526969944919886135E-01 -0.9437168746105094596643E+00  0.3203631239422585763599E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1179                             0                             0                             0                             0                             0                             0
 -0.1112942894511528696411E+00  0.1226772314110201045345E+00  0.7483972878355087399171E+00 -0.1217588085678561610203E+00 -0.9437168746105093486420E+00  0.3075276460930109756475E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1180                             0                             0                             0                             0                             0                             0
 -0.1456475327674178754656E+00  0.1226772314110201045345E+00  0.7322318785870808310889E+00 -0.1593421382899613825135E+00 -0.9437168746105093486420E+00  0.2898422735567654506816E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1181                             0                             0                             0                             0                             0                             0
 -0.1777038274863217415245E+00  0.1226772314110201045345E+00  0.7118883353507019506878E+00 -0.1944125473048541330456E+00 -0.9437168746105095706866E+00  0.2675859152231483406581E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1182                             0                             0                             0                             0                             0                             0
 -0.2069576266906455186412E+00  0.1226772314110201045345E+00  0.6876874879558529940482E+00 -0.2264169543123231431725E+00 -0.9437168746105094596643E+00  0.2411095671583843025321E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1183                             0                             0                             0                             0                             0                             0
 -0.2329475804915643044612E+00  0.1226772314110201045345E+00  0.6600109982228361538148E+00 -0.2548506306953544631178E+00 -0.9437168746105094596643E+00  0.2108307771876585245963E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1184                             0                             0                             0                             0                             0                             0
 -0.2552638117919915905496E+00  0.1226772314110201045345E+00  0.6292953409278752019418E+00 -0.2792651603919324987402E+00 -0.9437168746105093486420E+00  0.1772270599164818827287E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1185                             0                             0                             0                             0                             0                             0
 -0.2735543802932492996050E+00  0.1226772314110201045345E+00  0.5960249203351555280506E+00 -0.2992755116842092388829E+00 -0.9437168746105094596643E+00  0.1408283660401084824709E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1186                             0                             0                             0                             0                             0                             0
 -0.2875308328038165828211E+00  0.1226772314110201045345E+00  0.5607244308522106868153E+00 -0.3145661093787009421341E+00 -0.9437168746105094596643E+00  0.1022087247044947411201E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1187                             0                             0                             0                             0                             0                             0
 -0.2969727523184738648965E+00  0.1226772314110201045345E+00  0.5239505822856763694872E+00 -0.3248958116156053788082E+00 -0.9437168746105094596643E+00  0.6197719072375823534671E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1188                             0                             0                             0                             0                             0                             0
 -0.3017312341261456087871E+00  0.1226772314110201045345E+00  0.4862833201950794714818E+00 -0.3301017128199814076872E+00 -0.9437168746105093486420E+00  0.2076823942192890237735E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1189                             0                             0                             0                             0                             0                             0
 -0.3017312341261456087871E+00  0.1226772314110201045345E+00  0.4483166798049205703514E+00 -0.3301017128199814076872E+00 -0.9437168746105093486420E+00 -0.2076823942192882604951E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1190                             0                             0                             0                             0                             0                             0
 -0.2969727523184738648965E+00  0.1226772314110201045345E+00  0.4106494177143236723460E+00 -0.3248958116156053788082E+00 -0.9437168746105093486420E+00 -0.6197719072375815207998E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1191                             0                             0                             0                             0                             0                             0
 -0.2875308328038165828211E+00  0.1226772314110201045345E+00  0.3738755691477893550179E+00 -0.3145661093787009976452E+00 -0.9437168746105095706866E+00 -0.1022087247044946578534E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1192                             0                             0                             0                             0                             0                             0
 -0.2735543802932493551161E+00  0.1226772314110201045345E+00  0.3385750796648445137826E+00 -0.2992755116842092943941E+00 -0.9437168746105093486420E+00 -0.1408283660401083992042E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1193                             0                             0                             0                             0                             0                             0
 -0.2552638117919914795273E+00  0.1226772314110201045345E+00  0.3053046590721246733580E+00 -0.2792651603919323877179E+00 -0.9437168746105094596643E+00 -0.1772270599164820492621E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1194                             0                             0                             0                             0                             0                             0
 -0.2329475804915643599724E+00  0.1226772314110201045345E+00  0.2745890017771638325073E+00 -0.2548506306953545186289E+00 -0.9437168746105095706866E+00 -0.2108307771876584413295E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1195                             0                             0                             0                             0                             0                             0
 -0.2069576266906456851746E+00  0.1226772314110201045345E+00  0.2469125120441471865629E+00 -0.2264169543123233374615E+00 -0.9437168746105095706866E+00 -0.2411095671583841359986E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1196                             0                             0                             0                             0                             0                             0
 -0.1777038274863219080579E+00  0.1226772314110201045345E+00  0.2227116646492982021677E+00 -0.1944125473048542995791E+00 -0.9437168746105093486420E+00 -0.2675859152231481741246E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1197                             0                             0                             0                             0                             0                             0
 -0.1456475327674180697546E+00  0.1226772314110201045345E+00  0.2023681214129192662554E+00 -0.1593421382899616045581E+00 -0.9437168746105094596643E+00 -0.2898422735567653396593E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1198                             0                             0                             0                             0                             0                             0
 -0.1112942894511528280077E+00  0.1226772314110201045345E+00  0.1862027121644913019161E+00 -0.1217588085678561055092E+00 -0.9437168746105094596643E+00 -0.3075276460930109756475E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1199                             0                             0                             0                             0                             0                             0
 -0.7518586870625745821606E-01  0.1226772314110201045345E+00  0.1744703750646099393862E+00 -0.8225526969944942090596E-01 -0.9437168746105094596643E+00 -0.3203631239422585208487E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1200                             0                             0                             0                             0                             0                             0
 -0.3789172189800325135645E-01  0.1226772314110201045345E+00  0.1673561360778983986286E+00 -0.4145451609096579420610E-01 -0.9437168746105094596643E+00 -0.3281462839512827578403E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1201                             0                             0                             0                             0                             0                             0
  0.1642863681056174140932E-16  0.1150000000000000049960E+00  0.1990000000000000102141E+00  0.3548016375458390791401E-17 -0.9983198637050665347203E+00 -0.5794350465666767147077E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1202                             0                             0                             0                             0                             0                             0
  0.3362690656530283039860E-01  0.1150000000000000049960E+00  0.2011156256373256012715E+00  0.7262246802668480272214E-02 -0.9983198637050666457426E+00 -0.5748660281556390583280E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1203                             0                             0                             0                             0                             0                             0
  0.6672349672633051675952E-01  0.1150000000000000049960E+00  0.2074291378691883180885E+00  0.1440996363500291789495E-01 -0.9983198637050664236980E+00 -0.5612310290722672539987E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1204                             0                             0                             0                             0                             0                             0
  0.9876781748529912807744E-01  0.1150000000000000049960E+00  0.2178409688361821749947E+00  0.2133042673271834735460E-01 -0.9983198637050665347203E+00 -0.5387450813972599616974E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1205                             0                             0                             0                             0                             0                             0
  0.1292545107614902211157E+00  0.1150000000000000049960E+00  0.2321869177442314191584E+00  0.2791449625867950187774E-01 -0.9983198637050666457426E+00 -0.5077628019579059903688E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1206                             0                             0                             0                             0                             0                             0
  0.1577027831900705279189E+00  0.1150000000000000049960E+00  0.2502407404092016340869E+00  0.3405833750332949716455E-01 -0.9983198637050665347203E+00 -0.4687727998088805220211E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1207                             0                             0                             0                             0                             0                             0
  0.1836639885206671485296E+00  0.1150000000000000049960E+00  0.2717177172628352788131E+00  0.3966505842008734988857E-01 -0.9983198637050665347203E+00 -0.4223899705755720240807E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1208                             0                             0                             0                             0                             0                             0
  0.2067287030367442324241E+00  0.1150000000000000049960E+00  0.2962791435504266157608E+00  0.4464623767080305033472E-01 -0.9983198637050664236980E+00 -0.3693457991827488184899E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1209                             0                             0                             0                             0                             0                             0
  0.2265331824121906700853E+00  0.1150000000000000049960E+00  0.3235376709071352552272E+00  0.4892331908308057003554E-01 -0.9983198637050667567649E+00 -0.3104768239003280125288E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1210                             0                             0                             0                             0                             0                             0
  0.2427650981766330262612E+00  0.1150000000000000049960E+00  0.3530634160730909965054E+00  0.5242885052804369117041E-01 -0.9983198637050666457426E+00 -0.2467114436351344752829E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1211                             0                             0                             0                             0                             0                             0
  0.2551684633219896691791E+00  0.1150000000000000049960E+00  0.3843907404092016255603E+00  0.5510754768070236231381E-01 -0.9983198637050664236980E+00 -0.1790552765255421299728E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1212                             0                             0                             0                             0                             0                             0
  0.2635476693705071649099E+00  0.1150000000000000049960E+00  0.4170255932966500656001E+00  0.5691716588678306237847E-01 -0.9983198637050665347203E+00 -0.1085753007427044634914E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1213                             0                             0                             0                             0                             0                             0
  0.2677705712373052437947E+00  0.1150000000000000049960E+00  0.4504533036102851828453E+00  0.5782916638616235338599E-01 -0.9983198637050664236980E+00 -0.3638302760741356570162E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1214                             0                             0                             0                             0                             0                             0
  0.2677705712373052437947E+00  0.1150000000000000049960E+00  0.4841466963897148034768E+00  0.5782916638616235338599E-01 -0.9983198637050664236980E+00  0.3638302760741356570162E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1215                             0                             0                             0                             0                             0                             0
  0.2635476693705071649099E+00  0.1150000000000000049960E+00  0.5175744067033498652108E+00  0.5691716588678306237847E-01 -0.9983198637050665347203E+00  0.1085753007427044634914E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1216                             0                             0                             0                             0                             0                             0
  0.2551684633219897246903E+00  0.1150000000000000049960E+00  0.5502092595907983607617E+00  0.5510754768070236925270E-01 -0.9983198637050665347203E+00  0.1790552765255419911949E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1217                             0                             0                             0                             0                             0                             0
  0.2427650981766329985057E+00  0.1150000000000000049960E+00  0.5815365839269089898167E+00  0.5242885052804368423152E-01 -0.9983198637050665347203E+00  0.2467114436351345793663E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1218                             0                             0                             0                             0                             0                             0
  0.2265331824121905590630E+00  0.1150000000000000049960E+00  0.6110623290928648421172E+00  0.4892331908308054921886E-01 -0.9983198637050665347203E+00  0.3104768239003281860011E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1219                             0                             0                             0                             0                             0                             0
  0.2067287030367442046686E+00  0.1150000000000000049960E+00  0.6383208564495734815836E+00  0.4464623767080304339583E-01 -0.9983198637050665347203E+00  0.3693457991827488878789E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1220                             0                             0                             0                             0                             0                             0
  0.1836639885206672040407E+00  0.1150000000000000049960E+00  0.6628822827371646519978E+00  0.3966505842008735682747E-01 -0.9983198637050665347203E+00  0.4223899705755718853029E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1221                             0                             0                             0                             0                             0                             0
  0.1577027831900705279189E+00  0.1150000000000000049960E+00  0.6843592595907983522352E+00  0.3405833750332949716455E-01 -0.9983198637050665347203E+00  0.4687727998088805220211E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1222                             0                             0                             0                             0                             0                             0
  0.1292545107614901656046E+00  0.1150000000000000049960E+00  0.7024130822557685949192E+00  0.2791449625867949146940E-01 -0.9983198637050667567649E+00  0.5077628019579060597577E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1223                             0                             0                             0                             0                             0                             0
  0.9876781748529912807744E-01  0.1150000000000000049960E+00  0.7167590311638177835718E+00  0.2133042673271834735460E-01 -0.9983198637050665347203E+00  0.5387450813972599616974E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1224                             0                             0                             0                             0                             0                             0
  0.6672349672633064165961E-01  0.1150000000000000049960E+00  0.7271708621308117237447E+00  0.1440996363500294391580E-01 -0.9983198637050664236980E+00  0.5612310290722671846098E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1225                             0                             0                             0                             0                             0                             0
  0.3362690656530289284865E-01  0.1150000000000000049960E+00  0.7334843743626744405617E+00  0.7262246802668493282640E-02 -0.9983198637050665347203E+00  0.5748660281556389889390E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1226                             0                             0                             0                             0                             0                             0
  0.1642863681056174140932E-16  0.1150000000000000049960E+00  0.7356000000000000316192E+00  0.3548016375458390791401E-17 -0.9983198637050665347203E+00  0.5794350465666767147077E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1227                             0                             0                             0                             0                             0                             0
 -0.3362690656530285815418E-01  0.1150000000000000049960E+00  0.7334843743626744405617E+00 -0.7262246802668487211108E-02 -0.9983198637050664236980E+00  0.5748660281556389889390E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1228                             0                             0                             0                             0                             0                             0
 -0.6672349672633048900394E-01  0.1150000000000000049960E+00  0.7271708621308117237447E+00 -0.1440996363500291269077E-01 -0.9983198637050666457426E+00  0.5612310290722673233876E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1229                             0                             0                             0                             0                             0                             0
 -0.9876781748529910032186E-01  0.1150000000000000049960E+00  0.7167590311638177835718E+00 -0.2133042673271834041571E-01 -0.9983198637050664236980E+00  0.5387450813972599616974E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1230                             0                             0                             0                             0                             0                             0
 -0.1292545107614902488713E+00  0.1150000000000000049960E+00  0.7024130822557685949192E+00 -0.2791449625867950881664E-01 -0.9983198637050665347203E+00  0.5077628019579059209798E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1231                             0                             0                             0                             0                             0                             0
 -0.1577027831900704168966E+00  0.1150000000000000049960E+00  0.6843592595907984632575E+00 -0.3405833750332947634787E-01 -0.9983198637050666457426E+00  0.4687727998088807301880E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1232                             0                             0                             0                             0                             0                             0
 -0.1836639885206670930184E+00  0.1150000000000000049960E+00  0.6628822827371647630201E+00 -0.3966505842008733601078E-01 -0.9983198637050665347203E+00  0.4223899705755721628586E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1233                             0                             0                             0                             0                             0                             0
 -0.2067287030367442601797E+00  0.1150000000000000049960E+00  0.6383208564495733705613E+00 -0.4464623767080305727362E-01 -0.9983198637050665347203E+00  0.3693457991827487491010E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1234                             0                             0                             0                             0                             0                             0
 -0.2265331824121906978409E+00  0.1150000000000000049960E+00  0.6110623290928647310949E+00 -0.4892331908308057697443E-01 -0.9983198637050664236980E+00  0.3104768239003278043620E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1235                             0                             0                             0                             0                             0                             0
 -0.2427650981766331095280E+00  0.1150000000000000049960E+00  0.5815365839269088787944E+00 -0.5242885052804370504820E-01 -0.9983198637050665347203E+00  0.2467114436351341630327E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1236                             0                             0                             0                             0                             0                             0
 -0.2551684633219896691791E+00  0.1150000000000000049960E+00  0.5502092595907983607617E+00 -0.5510754768070236231381E-01 -0.9983198637050664236980E+00  0.1790552765255421993618E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1237                             0                             0                             0                             0                             0                             0
 -0.2635476693705071649099E+00  0.1150000000000000049960E+00  0.5175744067033498652108E+00 -0.5691716588678306237847E-01 -0.9983198637050665347203E+00  0.1085753007427044114497E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1238                             0                             0                             0                             0                             0                             0
 -0.2677705712373052437947E+00  0.1150000000000000049960E+00  0.4841466963897146924545E+00 -0.5782916638616235338599E-01 -0.9983198637050664236980E+00  0.3638302760741338355566E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1239                             0                             0                             0                             0                             0                             0
 -0.2677705712373052437947E+00  0.1150000000000000049960E+00  0.4504533036102853493787E+00 -0.5782916638616235338599E-01 -0.9983198637050664236980E+00 -0.3638302760741324477778E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1240                             0                             0                             0                             0                             0                             0
 -0.2635476693705071649099E+00  0.1150000000000000049960E+00  0.4170255932966501766224E+00 -0.5691716588678306237847E-01 -0.9983198637050664236980E+00 -0.1085753007427042726718E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1241                             0                             0                             0                             0                             0                             0
 -0.2551684633219897246903E+00  0.1150000000000000049960E+00  0.3843907404092016255603E+00 -0.5510754768070236925270E-01 -0.9983198637050665347203E+00 -0.1790552765255420605839E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1242                             0                             0                             0                             0                             0                             0
 -0.2427650981766331372835E+00  0.1150000000000000049960E+00  0.3530634160730912185500E+00 -0.5242885052804370504820E-01 -0.9983198637050665347203E+00 -0.2467114436351340589493E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1243                             0                             0                             0                             0                             0                             0
 -0.2265331824121905868186E+00  0.1150000000000000049960E+00  0.3235376709071351442049E+00 -0.4892331908308055615775E-01 -0.9983198637050665347203E+00 -0.3104768239003281166122E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1244                             0                             0                             0                             0                             0                             0
 -0.2067287030367443434464E+00  0.1150000000000000049960E+00  0.2962791435504266712719E+00 -0.4464623767080307115140E-01 -0.9983198637050665347203E+00 -0.3693457991827486797121E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1245                             0                             0                             0                             0                             0                             0
 -0.1836639885206672317963E+00  0.1150000000000000049960E+00  0.2717177172628353343242E+00 -0.3966505842008736376636E-01 -0.9983198637050666457426E+00 -0.4223899705755718853029E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1246                             0                             0                             0                             0                             0                             0
 -0.1577027831900705556745E+00  0.1150000000000000049960E+00  0.2502407404092016340869E+00 -0.3405833750332950410344E-01 -0.9983198637050665347203E+00 -0.4687727998088804526322E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1247                             0                             0                             0                             0                             0                             0
 -0.1292545107614904154048E+00  0.1150000000000000049960E+00  0.2321869177442315301807E+00 -0.2791449625867954351111E-01 -0.9983198637050665347203E+00 -0.5077628019579057128130E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1248                             0                             0                             0                             0                             0                             0
 -0.9876781748529904481071E-01  0.1150000000000000049960E+00  0.2178409688361821472391E+00 -0.2133042673271833347681E-01 -0.9983198637050665347203E+00 -0.5387450813972600310864E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1249                             0                             0                             0                             0                             0                             0
 -0.6672349672633066941518E-01  0.1150000000000000049960E+00  0.2074291378691883180885E+00 -0.1440996363500295085469E-01 -0.9983198637050664236980E+00 -0.5612310290722671846098E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1250                             0                             0                             0                             0                             0                             0
 -0.3362690656530292060422E-01  0.1150000000000000049960E+00  0.2011156256373256012715E+00 -0.7262246802668500221534E-02 -0.9983198637050665347203E+00 -0.5748660281556389889390E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
 LayPROP [Layup#, #ofLayer / Layerheight, PlyAngle, Material_ID]
              1              3
  0.5000000E-03  0.9000000E+02              1
  0.5000000E-02  0.0000000E+00              3
  0.5000000E-03  0.9000000E+02              1
              2              3
  0.5000000E-03  0.9000000E+02              1
  0.1000000E-03  0.0000000E+00              3
  0.5000000E-03  0.9000000E+02              1
              3              4
  0.5000000E-03  0.9000000E+02              1
  0.3000000E-03  0.2000000E+02              2
  0.3000000E-03  -0.200000E+02              2
  0.1000000E-02  0.0000000E+00              3
 MPROP [#ofMat, Mtype / Dense[kg/m3], H(m), E(Pa)/ nu, G(Pa)]
              1              2
  0.1000000E+04  0.7560000E+10  0.4740000E+08  0.4740000E+08
  0.4500000E+00  0.4500000E+00  0.4500000E+00  0.1634483E+08  0.1634483E+08  0.1634483E+08
              2              2
  0.2639000E+04  0.1800000E+12  0.4740000E+08  0.4740000E+08
  0.4500000E+00  0.4500000E+00  0.4500000E+00  0.1634483E+08  0.1634483E+08  0.1634483E+08
              3              2
  0.1100000E+04  0.4740000E+08  0.4740000E+08  0.4740000E+08
  0.4500000E+00  0.4500000E+00  0.4500000E+00  0.1634483E+08  0.1634483E+08  0.1634483E+08
              4              2
  0.1000000E+04  0.7560000E+10  0.4740000E+08  0.4740000E+08
  0.4500000E+00  0.4500000E+00  0.4500000E+00  0.1634483E+08  0.1634483E+08  0.1634483E+08
              5              2
  0.2639000E+04  0.1800000E+12  0.4740000E+08  0.4740000E+08
  0.4500000E+00  0.4500000E+00  0.4500000E+00  0.1634483E+08  0.1634483E+08  0.1634483E+08
              6              2
  0.1100000E+04  0.4740000E+08  0.4740000E+08  0.4740000E+08
  0.4500000E+00  0.4500000E+00  0.4500000E+00  0.1634483E+08  0.1634483E+08  0.1634483E+08
              7              2
  0.1000000E+04  0.6592500E+10  0.4740000E+08  0.4740000E+08
  0.4500000E+00  0.4500000E+00  0.4500000E+00  0.1634483E+08  0.1634483E+08  0.1634483E+08
