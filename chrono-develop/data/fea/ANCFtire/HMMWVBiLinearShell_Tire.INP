  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2643                             0                             0                             0                             0                             0                             0
  0.3515873675617279398020E-01  0.1354477585648095894211E+00  0.1327869647517004869641E+00  0.3499189590558118845287E-01 -0.9423036020307957727482E+00 -0.3329256505899185203390E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2644                             0                             0                             0                             0                             0                             0
  0.5261761250482472479506E-01  0.1354477585648095894211E+00  0.1350854693490785018994E+00  0.5236792300979863090671E-01 -0.9423036020307959947928E+00 -0.3306380532235020375253E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2645                             0                             0                             0                             0                             0                             0
  0.6993226703500633745225E-01  0.1354477585648095894211E+00  0.1382945508830218384055E+00  0.6960041327709590164297E-01 -0.9423036020307958837705E+00 -0.3274441999355691690354E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2646                             0                             0                             0                             0                             0                             0
  0.8705524208217720050218E-01  0.1354477585648095894211E+00  0.1424054134841064023220E+00  0.8664213364946600492988E-01 -0.9423036020307959947928E+00 -0.3233528448559802592754E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2647                             0                             0                             0                             0                             0                             0
  0.1039396047619365742731E+00  0.1354477585648095894211E+00  0.1474067895636852476571E+00  0.1034463739559238482091E+00 -0.9423036020307957727482E+00 -0.3183752021046216684752E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2648                             0                             0                             0                             0                             0                             0
  0.1205390762097968276878E+00  0.1354477585648095894211E+00  0.1532849706975655812435E+00  0.1199670749418378090656E+00 -0.9423036020307959947928E+00 -0.3125249150542833698196E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2649                             0                             0                             0                             0                             0                             0
  0.1368081584283344365183E+00  0.1354477585648095894211E+00  0.1600238451998468591775E+00  0.1361589545141452528565E+00 -0.9423036020307957727482E+00 -0.3058180189351217270755E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2650                             0                             0                             0                             0                             0                             0
  0.1527022589940384977858E+00  0.1354477585648095894211E+00  0.1676049422839316904721E+00  0.1519776318564223793750E+00 -0.9423036020307957727482E+00 -0.2982728968832087379504E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2651                             0                             0                             0                             0                             0                             0
  0.1681778132820437587913E+00  0.1354477585648095894211E+00  0.1760074826896681488009E+00  0.1673797490736166626579E+00 -0.9423036020307958837705E+00 -0.2899102295536338247395E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2652                             0                             0                             0                             0                             0                             0
  0.1831924038737394733189E+00  0.1354477585648095894211E+00  0.1852084356378577156832E+00  0.1823230900330239379059E+00 -0.9423036020307959947928E+00 -0.2807529384362653646079E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2653                             0                             0                             0                             0                             0                             0
  0.1977048768199650974342E+00  0.1354477585648095894211E+00  0.1951825819560196184632E+00  0.1967666960757732674825E+00 -0.9423036020307959947928E+00 -0.2708261230295405663782E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2654                             0                             0                             0                             0                             0                             0
  0.2116754544411247052071E+00  0.1354477585648095894211E+00  0.2059025832023903546109E+00  0.2106709782816642562153E+00 -0.9423036020307957727482E+00 -0.2601569920444847250351E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2655                             0                             0                             0                             0                             0                             0
  0.2250658443550415943601E+00  0.1354477585648095894211E+00  0.2173390565986915712315E+00  0.2239978259796453485819E+00 -0.9423036020307957727482E+00 -0.2487747888275257945878E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2656                             0                             0                             0                             0                             0                             0
  0.2378393444337163487035E+00  0.1354477585648095894211E+00  0.2294606555662836167020E+00  0.2367107112065141849566E+00 -0.9423036020307958837705E+00 -0.2367107112065142404678E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2657                             0                             0                             0                             0                             0                             0
  0.2499609434013084496851E+00  0.1354477585648095894211E+00  0.2422341556449583988009E+00  0.2487747888275258223434E+00 -0.9423036020307959947928E+00 -0.2239978259796453485819E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2658                             0                             0                             0                             0                             0                             0
  0.2613974167976096940613E+00  0.1354477585648095894211E+00  0.2556245455588753157095E+00  0.2601569920444847805463E+00 -0.9423036020307958837705E+00 -0.2106709782816642284597E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2659                             0                             0                             0                             0                             0                             0
  0.2721174180439803746978E+00  0.1354477585648095894211E+00  0.2695951231800348679712E+00  0.2708261230295405663782E+00 -0.9423036020307959947928E+00 -0.1967666960757732674825E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2660                             0                             0                             0                             0                             0                             0
  0.2820915643621422774778E+00  0.1354477585648095894211E+00  0.2841075961262605198421E+00  0.2807529384362653646079E+00 -0.9423036020307959947928E+00 -0.1823230900330239379059E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2661                             0                             0                             0                             0                             0                             0
  0.2912925173103317888490E+00  0.1354477585648095894211E+00  0.2991221867179562066141E+00  0.2899102295536338247395E+00 -0.9423036020307957727482E+00 -0.1673797490736166904135E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2662                             0                             0                             0                             0                             0                             0
  0.2996950577160683582001E+00  0.1354477585648095894211E+00  0.3145977410059614953752E+00  0.2982728968832087934615E+00 -0.9423036020307958837705E+00 -0.1519776318564223516194E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2663                             0                             0                             0                             0                             0                             0
  0.3072761548001531339835E+00  0.1354477585648095894211E+00  0.3304918415716655566428E+00  0.3058180189351217270755E+00 -0.9423036020307958837705E+00 -0.1361589545141453083676E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2664                             0                             0                             0                             0                             0                             0
  0.3140150293024344119175E+00  0.1354477585648095894211E+00  0.3467609237902031793510E+00  0.3125249150542833698196E+00 -0.9423036020307958837705E+00 -0.1199670749418377951878E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2665                             0                             0                             0                             0                             0                             0
  0.3198932104363147455039E+00  0.1354477585648095894211E+00  0.3633603952380634050101E+00  0.3183752021046216684752E+00 -0.9423036020307957727482E+00 -0.1034463739559238343313E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2666                             0                             0                             0                             0                             0                             0
  0.3248945865158935908390E+00  0.1354477585648095894211E+00  0.3802447579178228065366E+00  0.3233528448559802592754E+00 -0.9423036020307959947928E+00 -0.8664213364946599105210E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2667                             0                             0                             0                             0                             0                             0
  0.3290054491169781547555E+00  0.1354477585648095894211E+00  0.3973677329649937250977E+00  0.3274441999355692245466E+00 -0.9423036020307959947928E+00 -0.6960041327709581837624E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2668                             0                             0                             0                             0                             0                             0
  0.3322145306509214912616E+00  0.1354477585648095894211E+00  0.4146823874951752753049E+00  0.3306380532235020375253E+00 -0.9423036020307959947928E+00 -0.5236792300979861009003E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2669                             0                             0                             0                             0                             0                             0
  0.3345130352482995061969E+00  0.1354477585648095894211E+00  0.4321412632438272338753E+00  0.3329256505899185203390E+00 -0.9423036020307957727482E+00 -0.3499189590558116763619E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2670                             0                             0                             0                             0                             0                             0
  0.3358946628677779711047E+00  0.1354477585648095894211E+00  0.4496965066460740234611E+00  0.3343007218894463172809E+00 -0.9423036020307957727482E+00 -0.1751995844694339415915E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2671                             0                             0                             0                             0                             0                             0
  0.3363556265640875730938E+00  0.1354477585648095894211E+00  0.4672999999999999376499E+00  0.3347594981472333808270E+00 -0.9423036020307958837705E+00 -0.7433154051100418620624E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2672                             0                             0                             0                             0                             0                             0
  0.3358946628677779711047E+00  0.1354477585648095894211E+00  0.4849034933539259628610E+00  0.3343007218894463172809E+00 -0.9423036020307957727482E+00  0.1751995844694339415915E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2673                             0                             0                             0                             0                             0                             0
  0.3345130352482995061969E+00  0.1354477585648095894211E+00  0.5024587367561728079579E+00  0.3329256505899185203390E+00 -0.9423036020307957727482E+00  0.3499189590558116763619E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2674                             0                             0                             0                             0                             0                             0
  0.3322145306509214912616E+00  0.1354477585648095894211E+00  0.5199176125048247110172E+00  0.3306380532235020375253E+00 -0.9423036020307959947928E+00  0.5236792300979861009003E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2675                             0                             0                             0                             0                             0                             0
  0.3290054491169781547555E+00  0.1354477585648095894211E+00  0.5372322670350062612243E+00  0.3274441999355691690354E+00 -0.9423036020307957727482E+00  0.6960041327709588776518E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2676                             0                             0                             0                             0                             0                             0
  0.3248945865158935908390E+00  0.1354477585648095894211E+00  0.5543552420821771242743E+00  0.3233528448559802592754E+00 -0.9423036020307959947928E+00  0.8664213364946599105210E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2677                             0                             0                             0                             0                             0                             0
  0.3198932104363147455039E+00  0.1354477585648095894211E+00  0.5712396047619365813119E+00  0.3183752021046216684752E+00 -0.9423036020307957727482E+00  0.1034463739559238343313E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2678                             0                             0                             0                             0                             0                             0
  0.3140150293024344119175E+00  0.1354477585648095894211E+00  0.5878390762097968069710E+00  0.3125249150542833698196E+00 -0.9423036020307958837705E+00  0.1199670749418377951878E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2679                             0                             0                             0                             0                             0                             0
  0.3072761548001531894947E+00  0.1354477585648095894211E+00  0.6041081584283344296793E+00  0.3058180189351217270755E+00 -0.9423036020307959947928E+00  0.1361589545141452528565E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2680                             0                             0                             0                             0                             0                             0
  0.2996950577160683582001E+00  0.1354477585648095894211E+00  0.6200022589940384909468E+00  0.2982728968832087934615E+00 -0.9423036020307958837705E+00  0.1519776318564223516194E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2681                             0                             0                             0                             0                             0                             0
  0.2912925173103318443601E+00  0.1354477585648095894211E+00  0.6354778132820437797079E+00  0.2899102295536338247395E+00 -0.9423036020307958837705E+00  0.1673797490736166349024E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2682                             0                             0                             0                             0                             0                             0
  0.2820915643621423329890E+00  0.1354477585648095894211E+00  0.6504924038737394109688E+00  0.2807529384362653646079E+00 -0.9423036020307958837705E+00  0.1823230900330238546392E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2683                             0                             0                             0                             0                             0                             0
  0.2721174180439803746978E+00  0.1354477585648095894211E+00  0.6650048768199651183508E+00  0.2708261230295405663782E+00 -0.9423036020307959947928E+00  0.1967666960757732674825E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2684                             0                             0                             0                             0                             0                             0
  0.2613974167976097495725E+00  0.1354477585648095894211E+00  0.6789754544411246151014E+00  0.2601569920444847805463E+00 -0.9423036020307957727482E+00  0.2106709782816642007042E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2685                             0                             0                             0                             0                             0                             0
  0.2499609434013085329518E+00  0.1354477585648095894211E+00  0.6923658443550415597656E+00  0.2487747888275259056101E+00 -0.9423036020307959947928E+00  0.2239978259796452653152E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2686                             0                             0                             0                             0                             0                             0
  0.2378393444337163764590E+00  0.1354477585648095894211E+00  0.7051393444337163973756E+00  0.2367107112065142404678E+00 -0.9423036020307958837705E+00  0.2367107112065141849566E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2687                             0                             0                             0                             0                             0                             0
  0.2250658443550416498713E+00  0.1354477585648095894211E+00  0.7172609434013084150905E+00  0.2239978259796453763375E+00 -0.9423036020307959947928E+00  0.2487747888275257945878E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2688                             0                             0                             0                             0                             0                             0
  0.2116754544411246774516E+00  0.1354477585648095894211E+00  0.7286974167976096872223E+00  0.2106709782816642284597E+00 -0.9423036020307958837705E+00  0.2601569920444847805463E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2689                             0                             0                             0                             0                             0                             0
  0.1977048768199650974342E+00  0.1354477585648095894211E+00  0.7394174180439803123477E+00  0.1967666960757732674825E+00 -0.9423036020307959947928E+00  0.2708261230295405663782E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2690                             0                             0                             0                             0                             0                             0
  0.1831924038737395010745E+00  0.1354477585648095894211E+00  0.7493915643621422706389E+00  0.1823230900330239656615E+00 -0.9423036020307957727482E+00  0.2807529384362653090967E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2691                             0                             0                             0                             0                             0                             0
  0.1681778132820437587913E+00  0.1354477585648095894211E+00  0.7585925173103318375212E+00  0.1673797490736166626579E+00 -0.9423036020307958837705E+00  0.2899102295536338247395E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2692                             0                             0                             0                             0                             0                             0
  0.1527022589940384977858E+00  0.1354477585648095894211E+00  0.7669950577160682403388E+00  0.1519776318564223793750E+00 -0.9423036020307957727482E+00  0.2982728968832087379504E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2693                             0                             0                             0                             0                             0                             0
  0.1368081584283343532515E+00  0.1354477585648095894211E+00  0.7745761548001531826557E+00  0.1361589545141451973453E+00 -0.9423036020307958837705E+00  0.3058180189351217270755E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2694                             0                             0                             0                             0                             0                             0
  0.1205390762097967582989E+00  0.1354477585648095894211E+00  0.7813150293024344605897E+00  0.1199670749418377396767E+00 -0.9423036020307957727482E+00  0.3125249150542833698196E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2695                             0                             0                             0                             0                             0                             0
  0.1039396047619365742731E+00  0.1354477585648095894211E+00  0.7871932104363147386650E+00  0.1034463739559238482091E+00 -0.9423036020307957727482E+00  0.3183752021046216684752E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2696                             0                             0                             0                             0                             0                             0
  0.8705524208217713111324E-01  0.1354477585648095894211E+00  0.7921945865158935840000E+00  0.8664213364946593554095E-01 -0.9423036020307958837705E+00  0.3233528448559802592754E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2697                             0                             0                             0                             0                             0                             0
  0.6993226703500625418553E-01  0.1354477585648095894211E+00  0.7963054491169780924054E+00  0.6960041327709583225403E-01 -0.9423036020307959947928E+00  0.3274441999355692245466E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2698                             0                             0                             0                             0                             0                             0
  0.5261761250482472479506E-01  0.1354477585648095894211E+00  0.7995145306509214844226E+00  0.5236792300979863090671E-01 -0.9423036020307959947928E+00  0.3306380532235020375253E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2699                             0                             0                             0                             0                             0                             0
  0.3515873675617271765237E-01  0.1354477585648095894211E+00  0.8018130352482994993579E+00  0.3499189590558111906393E-01 -0.9423036020307959947928E+00  0.3329256505899185758501E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2700                             0                             0                             0                             0                             0                             0
  0.1760349335392601480277E-01  0.1354477585648095894211E+00  0.8031946628677779642658E+00  0.1751995844694341497583E-01 -0.9423036020307957727482E+00  0.3343007218894463172809E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2701                             0                             0                             0                             0                             0                             0
  0.1699677465018140057222E-15  0.1354477585648095894211E+00  0.8036556265640875107437E+00  0.1691611884165175616698E-15 -0.9423036020307958837705E+00  0.3347594981472333808270E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2702                             0                             0                             0                             0                             0                             0
 -0.1760349335392597316940E-01  0.1354477585648095894211E+00  0.8031946628677779642658E+00 -0.1751995844694337334246E-01 -0.9423036020307957727482E+00  0.3343007218894463172809E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2703                             0                             0                             0                             0                             0                             0
 -0.3515873675617267601901E-01  0.1354477585648095894211E+00  0.8018130352482994993579E+00 -0.3499189590558107049167E-01 -0.9423036020307959947928E+00  0.3329256505899185758501E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2704                             0                             0                             0                             0                             0                             0
 -0.5261761250482469010059E-01  0.1354477585648095894211E+00  0.7995145306509214844226E+00 -0.5236792300979858927334E-01 -0.9423036020307959947928E+00  0.3306380532235020375253E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2705                             0                             0                             0                             0                             0                             0
 -0.6993226703500622642995E-01  0.1354477585648095894211E+00  0.7963054491169780924054E+00 -0.6960041327709579062066E-01 -0.9423036020307959947928E+00  0.3274441999355692245466E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2706                             0                             0                             0                             0                             0                             0
 -0.8705524208217708947988E-01  0.1354477585648095894211E+00  0.7921945865158936950223E+00 -0.8664213364946589390758E-01 -0.9423036020307959947928E+00  0.3233528448559802592754E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2707                             0                             0                             0                             0                             0                             0
 -0.1039396047619365326398E+00  0.1354477585648095894211E+00  0.7871932104363147386650E+00 -0.1034463739559238065757E+00 -0.9423036020307959947928E+00  0.3183752021046217239864E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2708                             0                             0                             0                             0                             0                             0
 -0.1205390762097967166655E+00  0.1354477585648095894211E+00  0.7813150293024344605897E+00 -0.1199670749418376980433E+00 -0.9423036020307958837705E+00  0.3125249150542833698196E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2709                             0                             0                             0                             0                             0                             0
 -0.1368081584283344365183E+00  0.1354477585648095894211E+00  0.7745761548001530716334E+00 -0.1361589545141452806121E+00 -0.9423036020307958837705E+00  0.3058180189351217270755E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2710                             0                             0                             0                             0                             0                             0
 -0.1527022589940384700302E+00  0.1354477585648095894211E+00  0.7669950577160683513611E+00 -0.1519776318564223516194E+00 -0.9423036020307957727482E+00  0.2982728968832087934615E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2711                             0                             0                             0                             0                             0                             0
 -0.1681778132820437032802E+00  0.1354477585648095894211E+00  0.7585925173103318375212E+00 -0.1673797490736166071468E+00 -0.9423036020307957727482E+00  0.2899102295536338247395E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2712                             0                             0                             0                             0                             0                             0
 -0.1831924038737394733189E+00  0.1354477585648095894211E+00  0.7493915643621422706389E+00 -0.1823230900330239379059E+00 -0.9423036020307957727482E+00  0.2807529384362653090967E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2713                             0                             0                             0                             0                             0                             0
 -0.1977048768199650696786E+00  0.1354477585648095894211E+00  0.7394174180439803123477E+00 -0.1967666960757732397269E+00 -0.9423036020307957727482E+00  0.2708261230295405663782E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2714                             0                             0                             0                             0                             0                             0
 -0.2116754544411246219404E+00  0.1354477585648095894211E+00  0.7286974167976096872223E+00 -0.2106709782816642007042E+00 -0.9423036020307957727482E+00  0.2601569920444847805463E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2715                             0                             0                             0                             0                             0                             0
 -0.2250658443550415943601E+00  0.1354477585648095894211E+00  0.7172609434013084150905E+00 -0.2239978259796453485819E+00 -0.9423036020307959947928E+00  0.2487747888275258223434E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2716                             0                             0                             0                             0                             0                             0
 -0.2378393444337163487035E+00  0.1354477585648095894211E+00  0.7051393444337163973756E+00 -0.2367107112065141849566E+00 -0.9423036020307958837705E+00  0.2367107112065142404678E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2717                             0                             0                             0                             0                             0                             0
 -0.2499609434013083664183E+00  0.1354477585648095894211E+00  0.6923658443550416707879E+00 -0.2487747888275257668322E+00 -0.9423036020307957727482E+00  0.2239978259796453763375E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2718                             0                             0                             0                             0                             0                             0
 -0.2613974167976096385502E+00  0.1354477585648095894211E+00  0.6789754544411248371460E+00 -0.2601569920444846695240E+00 -0.9423036020307959947928E+00  0.2106709782816643394820E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2719                             0                             0                             0                             0                             0                             0
 -0.2721174180439803191867E+00  0.1354477585648095894211E+00  0.6650048768199651183508E+00 -0.2708261230295405108670E+00 -0.9423036020307957727482E+00  0.1967666960757732952381E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2720                             0                             0                             0                             0                             0                             0
 -0.2820915643621423329890E+00  0.1354477585648095894211E+00  0.6504924038737394109688E+00 -0.2807529384362653646079E+00 -0.9423036020307959947928E+00  0.1823230900330239101503E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2721                             0                             0                             0                             0                             0                             0
 -0.2912925173103317333378E+00  0.1354477585648095894211E+00  0.6354778132820438907302E+00 -0.2899102295536337692283E+00 -0.9423036020307958837705E+00  0.1673797490736168014358E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2722                             0                             0                             0                             0                             0                             0
 -0.2996950577160683026889E+00  0.1354477585648095894211E+00  0.6200022589940384909468E+00 -0.2982728968832087379504E+00 -0.9423036020307958837705E+00  0.1519776318564224071306E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2723                             0                             0                             0                             0                             0                             0
 -0.3072761548001530784724E+00  0.1354477585648095894211E+00  0.6041081584283346517239E+00 -0.3058180189351216160532E+00 -0.9423036020307958837705E+00  0.1361589545141454749011E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2724                             0                             0                             0                             0                             0                             0
 -0.3140150293024344674286E+00  0.1354477585648095894211E+00  0.5878390762097966959487E+00 -0.3125249150542834253308E+00 -0.9423036020307958837705E+00  0.1199670749418376286544E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2725                             0                             0                             0                             0                             0                             0
 -0.3198932104363147455039E+00  0.1354477585648095894211E+00  0.5712396047619365813119E+00 -0.3183752021046216684752E+00 -0.9423036020307957727482E+00  0.1034463739559238620869E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2726                             0                             0                             0                             0                             0                             0
 -0.3248945865158935908390E+00  0.1354477585648095894211E+00  0.5543552420821771242743E+00 -0.3233528448559802592754E+00 -0.9423036020307958837705E+00  0.8664213364946594941873E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2727                             0                             0                             0                             0                             0                             0
 -0.3290054491169781547555E+00  0.1354477585648095894211E+00  0.5372322670350063722466E+00 -0.3274441999355691690354E+00 -0.9423036020307959947928E+00  0.6960041327709599878748E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2728                             0                             0                             0                             0                             0                             0
 -0.3322145306509214357504E+00  0.1354477585648095894211E+00  0.5199176125048247110172E+00 -0.3306380532235019820142E+00 -0.9423036020307957727482E+00  0.5236792300979864478450E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2729                             0                             0                             0                             0                             0                             0
 -0.3345130352482995061969E+00  0.1354477585648095894211E+00  0.5024587367561730300025E+00 -0.3329256505899185203390E+00 -0.9423036020307958837705E+00  0.3499189590558143131416E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2730                             0                             0                             0                             0                             0                             0
 -0.3358946628677779711047E+00  0.1354477585648095894211E+00  0.4849034933539259073498E+00 -0.3343007218894463172809E+00 -0.9423036020307959947928E+00  0.1751995844694328660629E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2731                             0                             0                             0                             0                             0                             0
 -0.3363556265640875730938E+00  0.1354477585648095894211E+00  0.4673000000000000486722E+00 -0.3347594981472333808270E+00 -0.9423036020307958837705E+00  0.4099621478901836618866E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2732                             0                             0                             0                             0                             0                             0
 -0.3358946628677779711047E+00  0.1354477585648095894211E+00  0.4496965066460739124388E+00 -0.3343007218894463172809E+00 -0.9423036020307957727482E+00 -0.1751995844694349824255E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2733                             0                             0                             0                             0                             0                             0
 -0.3345130352482995617081E+00  0.1354477585648095894211E+00  0.4321412632438273448976E+00 -0.3329256505899185758501E+00 -0.9423036020307958837705E+00 -0.3499189590558105661389E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2734                             0                             0                             0                             0                             0                             0
 -0.3322145306509214912616E+00  0.1354477585648095894211E+00  0.4146823874951753308160E+00 -0.3306380532235020375253E+00 -0.9423036020307958837705E+00 -0.5236792300979856151777E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2735                             0                             0                             0                             0                             0                             0
 -0.3290054491169781547555E+00  0.1354477585648095894211E+00  0.3973677329649936140754E+00 -0.3274441999355691690354E+00 -0.9423036020307958837705E+00 -0.6960041327709592939854E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2736                             0                             0                             0                             0                             0                             0
 -0.3248945865158935353278E+00  0.1354477585648095894211E+00  0.3802447579178226400032E+00 -0.3233528448559802037643E+00 -0.9423036020307959947928E+00 -0.8664213364946615758555E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2737                             0                             0                             0                             0                             0                             0
 -0.3198932104363147455039E+00  0.1354477585648095894211E+00  0.3633603952380634605213E+00 -0.3183752021046217239864E+00 -0.9423036020307958837705E+00 -0.1034463739559237926979E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2738                             0                             0                             0                             0                             0                             0
 -0.3140150293024344674286E+00  0.1354477585648095894211E+00  0.3467609237902034013956E+00 -0.3125249150542834253308E+00 -0.9423036020307957727482E+00 -0.1199670749418375453876E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2739                             0                             0                             0                             0                             0                             0
 -0.3072761548001531894947E+00  0.1354477585648095894211E+00  0.3304918415716656676651E+00 -0.3058180189351217825866E+00 -0.9423036020307958837705E+00 -0.1361589545141451418342E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2740                             0                             0                             0                             0                             0                             0
 -0.2996950577160683582001E+00  0.1354477585648095894211E+00  0.3145977410059614953752E+00 -0.2982728968832087934615E+00 -0.9423036020307957727482E+00 -0.1519776318564223516194E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2741                             0                             0                             0                             0                             0                             0
 -0.2912925173103317888490E+00  0.1354477585648095894211E+00  0.2991221867179562066141E+00 -0.2899102295536338247395E+00 -0.9423036020307958837705E+00 -0.1673797490736167181691E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2742                             0                             0                             0                             0                             0                             0
 -0.2820915643621423329890E+00  0.1354477585648095894211E+00  0.2841075961262606308644E+00 -0.2807529384362654201190E+00 -0.9423036020307959947928E+00 -0.1823230900330238268836E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2743                             0                             0                             0                             0                             0                             0
 -0.2721174180439803746978E+00  0.1354477585648095894211E+00  0.2695951231800349234824E+00 -0.2708261230295405663782E+00 -0.9423036020307958837705E+00 -0.1967666960757732397269E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2744                             0                             0                             0                             0                             0                             0
 -0.2613974167976098605948E+00  0.1354477585648095894211E+00  0.2556245455588754822429E+00 -0.2601569920444848915686E+00 -0.9423036020307957727482E+00 -0.2106709782816640341707E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2745                             0                             0                             0                             0                             0                             0
 -0.2499609434013083386628E+00  0.1354477585648095894211E+00  0.2422341556449582877786E+00 -0.2487747888275257113211E+00 -0.9423036020307958837705E+00 -0.2239978259796454596042E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2746                             0                             0                             0                             0                             0                             0
 -0.2378393444337164042146E+00  0.1354477585648095894211E+00  0.2294606555662836444576E+00 -0.2367107112065142682233E+00 -0.9423036020307959947928E+00 -0.2367107112065141849566E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2747                             0                             0                             0                             0                             0                             0
 -0.2250658443550415666046E+00  0.1354477585648095894211E+00  0.2173390565986915157204E+00 -0.2239978259796453208264E+00 -0.9423036020307958837705E+00 -0.2487747888275258778545E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2748                             0                             0                             0                             0                             0                             0
 -0.2116754544411248162294E+00  0.1354477585648095894211E+00  0.2059025832023904101220E+00 -0.2106709782816643672376E+00 -0.9423036020307959947928E+00 -0.2601569920444846695240E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2749                             0                             0                             0                             0                             0                             0
 -0.1977048768199651251898E+00  0.1354477585648095894211E+00  0.1951825819560196739744E+00 -0.1967666960757732952381E+00 -0.9423036020307957727482E+00 -0.2708261230295405108670E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2750                             0                             0                             0                             0                             0                             0
 -0.1831924038737396953636E+00  0.1354477585648095894211E+00  0.1852084356378578822167E+00 -0.1823230900330241599505E+00 -0.9423036020307957727482E+00 -0.2807529384362651980744E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2751                             0                             0                             0                             0                             0                             0
 -0.1681778132820436477690E+00  0.1354477585648095894211E+00  0.1760074826896681488009E+00 -0.1673797490736165516356E+00 -0.9423036020307957727482E+00 -0.2899102295536338802506E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2752                             0                             0                             0                             0                             0                             0
 -0.1527022589940385255414E+00  0.1354477585648095894211E+00  0.1676049422839316904721E+00 -0.1519776318564224071306E+00 -0.9423036020307958837705E+00 -0.2982728968832087379504E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2753                             0                             0                             0                             0                             0                             0
 -0.1368081584283343810071E+00  0.1354477585648095894211E+00  0.1600238451998468036663E+00 -0.1361589545141452251009E+00 -0.9423036020307959947928E+00 -0.3058180189351217270755E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2754                             0                             0                             0                             0                             0                             0
 -0.1205390762097969387101E+00  0.1354477585648095894211E+00  0.1532849706975656367547E+00 -0.1199670749418379200879E+00 -0.9423036020307959947928E+00 -0.3125249150542833143085E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2755                             0                             0                             0                             0                             0                             0
 -0.1039396047619366159065E+00  0.1354477585648095894211E+00  0.1474067895636852476571E+00 -0.1034463739559238898424E+00 -0.9423036020307958837705E+00 -0.3183752021046216684752E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2756                             0                             0                             0                             0                             0                             0
 -0.8705524208217717274660E-01  0.1354477585648095894211E+00  0.1424054134841064023220E+00 -0.8664213364946596329652E-01 -0.9423036020307958837705E+00 -0.3233528448559802592754E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2757                             0                             0                             0                             0                             0                             0
 -0.6993226703500615704101E-01  0.1354477585648095894211E+00  0.1382945508830218384055E+00 -0.6960041327709573510951E-01 -0.9423036020307958837705E+00 -0.3274441999355692245466E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2758                             0                             0                             0                             0                             0                             0
 -0.5261761250482475948953E-01  0.1354477585648095894211E+00  0.1350854693490785574106E+00 -0.5236792300979866560118E-01 -0.9423036020307957727482E+00 -0.3306380532235019820142E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2759                             0                             0                             0                             0                             0                             0
 -0.3515873675617275928573E-01  0.1354477585648095894211E+00  0.1327869647517004314530E+00 -0.3499189590558116069730E-01 -0.9423036020307959947928E+00 -0.3329256505899185758501E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2760                             0                             0                             0                             0                             0                             0
 -0.1760349335392620215290E-01  0.1354477585648095894211E+00  0.1314053371322220220563E+00 -0.1751995844694360232596E-01 -0.9423036020307958837705E+00 -0.3343007218894463172809E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2761                             0                             0                             0                             0                             0                             0
  0.1851223917906933645146E-16  0.1226772314110201045345E+00  0.1649721910030176874606E+00  0.2025286470206510068544E-16 -0.9437168746105094596643E+00 -0.3307543810373069770314E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2762                             0                             0                             0                             0                             0                             0
  0.1582261498269118757398E-01  0.1226772314110201045345E+00  0.1653865207579738871857E+00  0.1731034681313051507012E-01 -0.9437168746105093486420E+00 -0.3303010936533228858458E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2763                             0                             0                             0                             0                             0                             0
  0.3160186127753121521078E-01  0.1226772314110201045345E+00  0.1666283743737838607402E+00  0.3457324716887359705719E-01 -0.9437168746105093486420E+00 -0.3289424739305826239644E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2764                             0                             0                             0                             0                             0                             0
  0.4729448906722803769309E-01  0.1226772314110201045345E+00  0.1686943480160068009610E+00  0.5174138465728381902631E-01 -0.9437168746105095706866E+00 -0.3266822457513096078507E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2765                             0                             0                             0                             0                             0                             0
  0.6285748594979122250148E-01  0.1226772314110201045345E+00  0.1715787789944935304298E+00  0.6876770260684797464457E-01 -0.9437168746105093486420E+00 -0.3235266042438367239953E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2766                             0                             0                             0                             0                             0                             0
  0.7824819483253624141650E-01  0.1226772314110201045345E+00  0.1752737612844262327094E+00  0.8560553306355107860970E-01 -0.9437168746105094596643E+00 -0.3194841988021900891503E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2767                             0                             0                             0                             0                             0                             0
  0.9342443085221066589874E-01  0.1226772314110201045345E+00  0.1797691671961834103399E+00  0.1022087247044947133645E+00 -0.9437168746105094596643E+00 -0.3145661093787009421341E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2768                             0                             0                             0                             0                             0                             0
  0.1083445970007717584771E+00  0.1226772314110201045345E+00  0.1850526751346326936876E+00  0.1185317693354646789716E+00 -0.9437168746105095706866E+00 -0.3087858161146270208341E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2769                             0                             0                             0                             0                             0                             0
  0.1229677981398942937519E+00  0.1226772314110201045345E+00  0.1911098033717669730791E+00  0.1345299266257283521409E+00 -0.9437168746105094596643E+00 -0.3021591623920217850596E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2770                             0                             0                             0                             0                             0                             0
  0.1372539530917022410073E+00  0.1226772314110201045345E+00  0.1979239497401140690513E+00  0.1501593467381714674946E+00 -0.9437168746105093486420E+00 -0.2947043114081258630144E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2771                             0                             0                             0                             0                             0                             0
  0.1511639044984911250946E+00  0.1226772314110201045345E+00  0.2054764371381237464398E+00  0.1653771905186534607601E+00 -0.9437168746105094596643E+00 -0.2864416963913058444824E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2772                             0                             0                             0                             0                             0                             0
  0.1646595261503238649681E+00  0.1226772314110201045345E+00  0.2137465647228051768280E+00  0.1801417469151514461068E+00 -0.9437168746105094596643E+00 -0.2773939645949954346804E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2773                             0                             0                             0                             0                             0                             0
  0.1777038274863218803024E+00  0.1226772314110201045345E+00  0.2227116646492981744121E+00  0.1944125473048542718235E+00 -0.9437168746105095706866E+00 -0.2675859152231482296358E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2774                             0                             0                             0                             0                             0                             0
  0.1902610549832214892341E+00  0.1226772314110201045345E+00  0.2323471642018607452584E+00  0.2081504764158449982681E+00 -0.9437168746105093486420E+00 -0.2570444314573431809912E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2775                             0                             0                             0                             0                             0                             0
  0.2022967901532958523436E+00  0.1226772314110201045345E+00  0.2426266531459746189636E+00  0.2213178795393420661419E+00 -0.9437168746105092376197E+00 -0.2457984067718530230007E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2776                             0                             0                             0                             0                             0                             0
  0.2137780438830374774017E+00  0.1226772314110201045345E+00  0.2535219561169624880037E+00  0.2338786657386389689073E+00 -0.9437168746105093486420E+00 -0.2338786657386389966629E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2777                             0                             0                             0                             0                             0                             0
  0.2246733468540254019530E+00  0.1226772314110201045345E+00  0.2650032098467041130618E+00  0.2457984067718530507562E+00 -0.9437168746105094596643E+00 -0.2213178795393420661419E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2778                             0                             0                             0                             0                             0                             0
  0.2349528357981392756582E+00  0.1226772314110201045345E+00  0.2770389450167785039270E+00  0.2570444314573432365023E+00 -0.9437168746105094596643E+00 -0.2081504764158449427569E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2779                             0                             0                             0                             0                             0                             0
  0.2445883353507018187489E+00  0.1226772314110201045345E+00  0.2895961725136780851031E+00  0.2675859152231482296358E+00 -0.9437168746105095706866E+00 -0.1944125473048542718235E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2780                             0                             0                             0                             0                             0                             0
  0.2535534352771948163330E+00  0.1226772314110201045345E+00  0.3026404738496761281930E+00  0.2773939645949954346804E+00 -0.9437168746105094596643E+00 -0.1801417469151514461068E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2781                             0                             0                             0                             0                             0                             0
  0.2618235628618762467212E+00  0.1226772314110201045345E+00  0.3161360955015088403108E+00  0.2864416963913058444824E+00 -0.9437168746105093486420E+00 -0.1653771905186534885157E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2782                             0                             0                             0                             0                             0                             0
  0.2693760502598859796208E+00  0.1226772314110201045345E+00  0.3300460469082977521538E+00  0.2947043114081259185255E+00 -0.9437168746105094596643E+00 -0.1501593467381714674946E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2783                             0                             0                             0                             0                             0                             0
  0.2761901966282330200819E+00  0.1226772314110201045345E+00  0.3443322018601056577758E+00  0.3021591623920217850596E+00 -0.9437168746105095706866E+00 -0.1345299266257283798964E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2784                             0                             0                             0                             0                             0                             0
  0.2822473248653672994735E+00  0.1226772314110201045345E+00  0.3589554029992282346839E+00  0.3087858161146270208341E+00 -0.9437168746105094596643E+00 -0.1185317693354646650938E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2785                             0                             0                             0                             0                             0                             0
  0.2875308328038165828211E+00  0.1226772314110201045345E+00  0.3738755691477893550179E+00  0.3145661093787009421341E+00 -0.9437168746105093486420E+00 -0.1022087247044946994867E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2786                             0                             0                             0                             0                             0                             0
  0.2920262387155737604516E+00  0.1226772314110201045345E+00  0.3890518051674637378667E+00  0.3194841988021900891503E+00 -0.9437168746105094596643E+00 -0.8560553306355106473191E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2787                             0                             0                             0                             0                             0                             0
  0.2957212210055065182424E+00  0.1226772314110201045345E+00  0.4044425140502088678041E+00  0.3235266042438367795064E+00 -0.9437168746105095706866E+00 -0.6876770260684787750005E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2788                             0                             0                             0                             0                             0                             0
  0.2986056519839931922000E+00  0.1226772314110201045345E+00  0.4200055109327719415901E+00  0.3266822457513096078507E+00 -0.9437168746105095706866E+00 -0.5174138465728379820963E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2789                             0                             0                             0                             0                             0                             0
  0.3006716256262161324209E+00  0.1226772314110201045345E+00  0.4356981387224688195836E+00  0.3289424739305826239644E+00 -0.9437168746105092376197E+00 -0.3457324716887357624051E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2790                             0                             0                             0                             0                             0                             0
  0.3019134792420261059753E+00  0.1226772314110201045345E+00  0.4514773850173088853843E+00  0.3303010936533228858458E+00 -0.9437168746105093486420E+00 -0.1731034681313041792561E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2791                             0                             0                             0                             0                             0                             0
  0.3023278089969823057004E+00  0.1226772314110201045345E+00  0.4672999999999999376499E+00  0.3307543810373069770314E+00 -0.9437168746105094596643E+00 -0.7344222586465209468707E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2792                             0                             0                             0                             0                             0                             0
  0.3019134792420261059753E+00  0.1226772314110201045345E+00  0.4831226149826911009377E+00  0.3303010936533228858458E+00 -0.9437168746105093486420E+00  0.1731034681313041792561E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2793                             0                             0                             0                             0                             0                             0
  0.3006716256262161324209E+00  0.1226772314110201045345E+00  0.4989018612775311667384E+00  0.3289424739305826239644E+00 -0.9437168746105092376197E+00  0.3457324716887357624051E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2794                             0                             0                             0                             0                             0                             0
  0.2986056519839931922000E+00  0.1226772314110201045345E+00  0.5145944890672280447319E+00  0.3266822457513096078507E+00 -0.9437168746105095706866E+00  0.5174138465728379820963E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2795                             0                             0                             0                             0                             0                             0
  0.2957212210055064627312E+00  0.1226772314110201045345E+00  0.5301574859497911740291E+00  0.3235266042438367239953E+00 -0.9437168746105093486420E+00  0.6876770260684794688899E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2796                             0                             0                             0                             0                             0                             0
  0.2920262387155737604516E+00  0.1226772314110201045345E+00  0.5455481948325362484553E+00  0.3194841988021900891503E+00 -0.9437168746105094596643E+00  0.8560553306355106473191E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2797                             0                             0                             0                             0                             0                             0
  0.2875308328038165828211E+00  0.1226772314110201045345E+00  0.5607244308522106868153E+00  0.3145661093787009421341E+00 -0.9437168746105093486420E+00  0.1022087247044946994867E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2798                             0                             0                             0                             0                             0                             0
  0.2822473248653672994735E+00  0.1226772314110201045345E+00  0.5756445970007717516381E+00  0.3087858161146270208341E+00 -0.9437168746105094596643E+00  0.1185317693354646650938E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2799                             0                             0                             0                             0                             0                             0
  0.2761901966282330755931E+00  0.1226772314110201045345E+00  0.5902677981398942730351E+00  0.3021591623920218405708E+00 -0.9437168746105095706866E+00  0.1345299266257283243853E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2800                             0                             0                             0                             0                             0                             0
  0.2693760502598859796208E+00  0.1226772314110201045345E+00  0.6045539530917022341683E+00  0.2947043114081259185255E+00 -0.9437168746105094596643E+00  0.1501593467381714674946E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2801                             0                             0                             0                             0                             0                             0
  0.2618235628618762467212E+00  0.1226772314110201045345E+00  0.6184639044984910905001E+00  0.2864416963913058444824E+00 -0.9437168746105093486420E+00  0.1653771905186534330046E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2802                             0                             0                             0                             0                             0                             0
  0.2535534352771948718441E+00  0.1226772314110201045345E+00  0.6319595261503238026179E+00  0.2773939645949954901916E+00 -0.9437168746105094596643E+00  0.1801417469151513628400E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2803                             0                             0                             0                             0                             0                             0
  0.2445883353507018187489E+00  0.1226772314110201045345E+00  0.6450038274863219012190E+00  0.2675859152231482296358E+00 -0.9437168746105095706866E+00  0.1944125473048542718235E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2804                             0                             0                             0                             0                             0                             0
  0.2349528357981393034137E+00  0.1226772314110201045345E+00  0.6575610549832213713728E+00  0.2570444314573432920135E+00 -0.9437168746105093486420E+00  0.2081504764158449150013E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2805                             0                             0                             0                             0                             0                             0
  0.2246733468540254574641E+00  0.1226772314110201045345E+00  0.6695967901532957622379E+00  0.2457984067718531340230E+00 -0.9437168746105095706866E+00  0.2213178795393419828752E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2806                             0                             0                             0                             0                             0                             0
  0.2137780438830375051573E+00  0.1226772314110201045345E+00  0.6810780438830374983183E+00  0.2338786657386389966629E+00 -0.9437168746105093486420E+00  0.2338786657386389689073E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2807                             0                             0                             0                             0                             0                             0
  0.2022967901532958800992E+00  0.1226772314110201045345E+00  0.6919733468540253396029E+00  0.2213178795393420938975E+00 -0.9437168746105093486420E+00  0.2457984067718530230007E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2808                             0                             0                             0                             0                             0                             0
  0.1902610549832214614785E+00  0.1226772314110201045345E+00  0.7022528357981392410636E+00  0.2081504764158449427569E+00 -0.9437168746105094596643E+00  0.2570444314573432365023E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2809                             0                             0                             0                             0                             0                             0
  0.1777038274863218803024E+00  0.1226772314110201045345E+00  0.7118883353507018396655E+00  0.1944125473048542718235E+00 -0.9437168746105095706866E+00  0.2675859152231482296358E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2810                             0                             0                             0                             0                             0                             0
  0.1646595261503238927236E+00  0.1226772314110201045345E+00  0.7208534352771948094940E+00  0.1801417469151514738623E+00 -0.9437168746105094596643E+00  0.2773939645949953791693E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2811                             0                             0                             0                             0                             0                             0
  0.1511639044984911250946E+00  0.1226772314110201045345E+00  0.7291235628618761843711E+00  0.1653771905186534607601E+00 -0.9437168746105094596643E+00  0.2864416963913058444824E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2812                             0                             0                             0                             0                             0                             0
  0.1372539530917022410073E+00  0.1226772314110201045345E+00  0.7366760502598859172707E+00  0.1501593467381714674946E+00 -0.9437168746105093486420E+00  0.2947043114081258630144E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2813                             0                             0                             0                             0                             0                             0
  0.1229677981398942243629E+00  0.1226772314110201045345E+00  0.7434901966282330132429E+00  0.1345299266257282688741E+00 -0.9437168746105095706866E+00  0.3021591623920218405708E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2814                             0                             0                             0                             0                             0                             0
  0.1083445970007717029659E+00  0.1226772314110201045345E+00  0.7495473248653672371233E+00  0.1185317693354646095827E+00 -0.9437168746105093486420E+00  0.3087858161146270208341E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2815                             0                             0                             0                             0                             0                             0
  0.9342443085221066589874E-01  0.1226772314110201045345E+00  0.7548308328038165759821E+00  0.1022087247044947133645E+00 -0.9437168746105094596643E+00  0.3145661093787009421341E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2816                             0                             0                             0                             0                             0                             0
  0.7824819483253617202756E-01  0.1226772314110201045345E+00  0.7593262387155736981015E+00  0.8560553306355100922076E-01 -0.9437168746105093486420E+00  0.3194841988021900891503E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
