                          1102                             1                             3                          1102                          1103                          1222                          1223
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1103                             1                             3                          1103                          1104                          1223                          1224
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1104                             1                             3                          1104                          1105                          1224                          1225
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1105                             1                             3                          1105                          1106                          1225                          1226
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1106                             1                             3                          1106                          1107                          1226                          1227
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1107                             1                             3                          1107                          1108                          1227                          1228
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1108                             1                             3                          1108                          1109                          1228                          1229
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1109                             1                             3                          1109                          1110                          1229                          1230
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1110                             1                             3                          1110                          1111                          1230                          1231
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1111                             1                             3                          1111                          1112                          1231                          1232
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1112                             1                             3                          1112                          1113                          1232                          1233
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1113                             1                             3                          1113                          1114                          1233                          1234
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1114                             1                             3                          1114                          1115                          1234                          1235
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1115                             1                             3                          1115                          1116                          1235                          1236
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1116                             1                             3                          1116                          1117                          1236                          1237
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1117                             1                             3                          1117                          1118                          1237                          1238
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1118                             1                             3                          1118                          1119                          1238                          1239
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1119                             1                             3                          1119                          1120                          1239                          1240
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1120                             1                             3                          1120                          1121                          1240                          1241
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1121                             1                             3                          1121                          1122                          1241                          1242
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1122                             1                             3                          1122                          1123                          1242                          1243
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1123                             1                             3                          1123                          1124                          1243                          1244
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1124                             1                             3                          1124                          1125                          1244                          1245
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1125                             1                             3                          1125                          1126                          1245                          1246
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1126                             1                             3                          1126                          1127                          1246                          1247
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1127                             1                             3                          1127                          1128                          1247                          1248
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1128                             1                             3                          1128                          1129                          1248                          1249
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1129                             1                             3                          1129                          1130                          1249                          1250
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1130                             1                             3                          1130                          1131                          1250                          1251
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1131                             1                             3                          1131                          1132                          1251                          1252
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1132                             1                             3                          1132                          1133                          1252                          1253
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1133                             1                             3                          1133                          1134                          1253                          1254
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1134                             1                             3                          1134                          1135                          1254                          1255
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1135                             1                             3                          1135                          1136                          1255                          1256
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1136                             1                             3                          1136                          1137                          1256                          1257
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1137                             1                             3                          1137                          1138                          1257                          1258
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1138                             1                             3                          1138                          1139                          1258                          1259
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1139                             1                             3                          1139                          1140                          1259                          1260
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1140                             1                             3                          1140                          1141                          1260                          1261
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1141                             1                             3                          1141                          1142                          1261                          1262
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1142                             1                             3                          1142                          1143                          1262                          1263
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1143                             1                             3                          1143                          1144                          1263                          1264
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1144                             1                             3                          1144                          1145                          1264                          1265
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1145                             1                             3                          1145                          1146                          1265                          1266
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1146                             1                             3                          1146                          1147                          1266                          1267
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1147                             1                             3                          1147                          1148                          1267                          1268
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1148                             1                             3                          1148                          1149                          1268                          1269
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1149                             1                             3                          1149                          1150                          1269                          1270
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1150                             1                             3                          1150                          1151                          1270                          1271
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1151                             1                             3                          1151                          1152                          1271                          1272
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1152                             1                             3                          1152                          1153                          1272                          1273
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1153                             1                             3                          1153                          1154                          1273                          1274
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1154                             1                             3                          1154                          1155                          1274                          1275
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1155                             1                             3                          1155                          1156                          1275                          1276
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1156                             1                             3                          1156                          1157                          1276                          1277
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1157                             1                             3                          1157                          1158                          1277                          1278
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1158                             1                             3                          1158                          1159                          1278                          1279
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1159                             1                             3                          1159                          1160                          1279                          1280
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1160                             1                             3                          1160                          1161                          1280                          1281
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1161                             1                             3                          1161                          1162                          1281                          1282
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1162                             1                             3                          1162                          1163                          1282                          1283
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1163                             1                             3                          1163                          1164                          1283                          1284
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1164                             1                             3                          1164                          1165                          1284                          1285
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1165                             1                             3                          1165                          1166                          1285                          1286
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1166                             1                             3                          1166                          1167                          1286                          1287
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1167                             1                             3                          1167                          1168                          1287                          1288
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1168                             1                             3                          1168                          1169                          1288                          1289
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1169                             1                             3                          1169                          1170                          1289                          1290
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1170                             1                             3                          1170                          1171                          1290                          1291
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1171                             1                             3                          1171                          1172                          1291                          1292
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1172                             1                             3                          1172                          1173                          1292                          1293
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1173                             1                             3                          1173                          1174                          1293                          1294
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1174                             1                             3                          1174                          1175                          1294                          1295
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1175                             1                             3                          1175                          1176                          1295                          1296
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1176                             1                             3                          1176                          1177                          1296                          1297
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1177                             1                             3                          1177                          1178                          1297                          1298
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1178                             1                             3                          1178                          1179                          1298                          1299
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1179                             1                             3                          1179                          1180                          1299                          1300
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1180                             1                             3                          1180                          1181                          1300                          1301
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1181                             1                             3                          1181                          1182                          1301                          1302
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1182                             1                             3                          1182                          1183                          1302                          1303
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1183                             1                             3                          1183                          1184                          1303                          1304
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1184                             1                             3                          1184                          1185                          1304                          1305
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1185                             1                             3                          1185                          1186                          1305                          1306
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1186                             1                             3                          1186                          1187                          1306                          1307
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1187                             1                             3                          1187                          1188                          1307                          1308
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1188                             1                             3                          1188                          1189                          1308                          1309
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1189                             1                             3                          1189                          1190                          1309                          1310
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1190                             1                             3                          1190                          1191                          1310                          1311
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1191                             1                             3                          1191                          1192                          1311                          1312
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1192                             1                             3                          1192                          1193                          1312                          1313
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1193                             1                             3                          1193                          1194                          1313                          1314
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1194                             1                             3                          1194                          1195                          1314                          1315
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1195                             1                             3                          1195                          1196                          1315                          1316
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1196                             1                             3                          1196                          1197                          1316                          1317
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1197                             1                             3                          1197                          1198                          1317                          1318
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1198                             1                             3                          1198                          1199                          1318                          1319
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1199                             1                             3                          1199                          1200                          1319                          1320
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1200                             1                             3                          1200                          1081                          1320                          1201
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1201                             1                             3                          1201                          1202                          1321                          1322
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1202                             1                             3                          1202                          1203                          1322                          1323
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1203                             1                             3                          1203                          1204                          1323                          1324
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1204                             1                             3                          1204                          1205                          1324                          1325
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1205                             1                             3                          1205                          1206                          1325                          1326
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1206                             1                             3                          1206                          1207                          1326                          1327
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1207                             1                             3                          1207                          1208                          1327                          1328
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1208                             1                             3                          1208                          1209                          1328                          1329
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1209                             1                             3                          1209                          1210                          1329                          1330
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1210                             1                             3                          1210                          1211                          1330                          1331
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1211                             1                             3                          1211                          1212                          1331                          1332
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1212                             1                             3                          1212                          1213                          1332                          1333
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1213                             1                             3                          1213                          1214                          1333                          1334
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1214                             1                             3                          1214                          1215                          1334                          1335
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1215                             1                             3                          1215                          1216                          1335                          1336
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1216                             1                             3                          1216                          1217                          1336                          1337
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1217                             1                             3                          1217                          1218                          1337                          1338
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1218                             1                             3                          1218                          1219                          1338                          1339
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1219                             1                             3                          1219                          1220                          1339                          1340
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1220                             1                             3                          1220                          1221                          1340                          1341
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1221                             1                             3                          1221                          1222                          1341                          1342
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1222                             1                             3                          1222                          1223                          1342                          1343
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1223                             1                             3                          1223                          1224                          1343                          1344
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1224                             1                             3                          1224                          1225                          1344                          1345
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1225                             1                             3                          1225                          1226                          1345                          1346
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1226                             1                             3                          1226                          1227                          1346                          1347
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1227                             1                             3                          1227                          1228                          1347                          1348
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1228                             1                             3                          1228                          1229                          1348                          1349
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1229                             1                             3                          1229                          1230                          1349                          1350
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1230                             1                             3                          1230                          1231                          1350                          1351
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1231                             1                             3                          1231                          1232                          1351                          1352
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1232                             1                             3                          1232                          1233                          1352                          1353
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1233                             1                             3                          1233                          1234                          1353                          1354
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1234                             1                             3                          1234                          1235                          1354                          1355
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1235                             1                             3                          1235                          1236                          1355                          1356
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1236                             1                             3                          1236                          1237                          1356                          1357
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1237                             1                             3                          1237                          1238                          1357                          1358
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1238                             1                             3                          1238                          1239                          1358                          1359
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1239                             1                             3                          1239                          1240                          1359                          1360
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1240                             1                             3                          1240                          1241                          1360                          1361
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1241                             1                             3                          1241                          1242                          1361                          1362
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1242                             1                             3                          1242                          1243                          1362                          1363
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1243                             1                             3                          1243                          1244                          1363                          1364
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1244                             1                             3                          1244                          1245                          1364                          1365
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1245                             1                             3                          1245                          1246                          1365                          1366
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1246                             1                             3                          1246                          1247                          1366                          1367
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1247                             1                             3                          1247                          1248                          1367                          1368
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1248                             1                             3                          1248                          1249                          1368                          1369
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1249                             1                             3                          1249                          1250                          1369                          1370
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1250                             1                             3                          1250                          1251                          1370                          1371
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1251                             1                             3                          1251                          1252                          1371                          1372
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1252                             1                             3                          1252                          1253                          1372                          1373
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1253                             1                             3                          1253                          1254                          1373                          1374
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1254                             1                             3                          1254                          1255                          1374                          1375
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1255                             1                             3                          1255                          1256                          1375                          1376
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1256                             1                             3                          1256                          1257                          1376                          1377
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1257                             1                             3                          1257                          1258                          1377                          1378
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1258                             1                             3                          1258                          1259                          1378                          1379
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1259                             1                             3                          1259                          1260                          1379                          1380
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1260                             1                             3                          1260                          1261                          1380                          1381
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1261                             1                             3                          1261                          1262                          1381                          1382
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1262                             1                             3                          1262                          1263                          1382                          1383
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1263                             1                             3                          1263                          1264                          1383                          1384
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1264                             1                             3                          1264                          1265                          1384                          1385
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1265                             1                             3                          1265                          1266                          1385                          1386
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1266                             1                             3                          1266                          1267                          1386                          1387
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1267                             1                             3                          1267                          1268                          1387                          1388
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1268                             1                             3                          1268                          1269                          1388                          1389
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1269                             1                             3                          1269                          1270                          1389                          1390
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1270                             1                             3                          1270                          1271                          1390                          1391
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1271                             1                             3                          1271                          1272                          1391                          1392
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1272                             1                             3                          1272                          1273                          1392                          1393
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1273                             1                             3                          1273                          1274                          1393                          1394
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1274                             1                             3                          1274                          1275                          1394                          1395
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1275                             1                             3                          1275                          1276                          1395                          1396
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1276                             1                             3                          1276                          1277                          1396                          1397
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1277                             1                             3                          1277                          1278                          1397                          1398
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1278                             1                             3                          1278                          1279                          1398                          1399
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1279                             1                             3                          1279                          1280                          1399                          1400
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1280                             1                             3                          1280                          1281                          1400                          1401
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1281                             1                             3                          1281                          1282                          1401                          1402
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1282                             1                             3                          1282                          1283                          1402                          1403
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1283                             1                             3                          1283                          1284                          1403                          1404
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1284                             1                             3                          1284                          1285                          1404                          1405
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1285                             1                             3                          1285                          1286                          1405                          1406
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1286                             1                             3                          1286                          1287                          1406                          1407
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1287                             1                             3                          1287                          1288                          1407                          1408
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1288                             1                             3                          1288                          1289                          1408                          1409
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1289                             1                             3                          1289                          1290                          1409                          1410
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1290                             1                             3                          1290                          1291                          1410                          1411
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1291                             1                             3                          1291                          1292                          1411                          1412
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1292                             1                             3                          1292                          1293                          1412                          1413
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1293                             1                             3                          1293                          1294                          1413                          1414
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1294                             1                             3                          1294                          1295                          1414                          1415
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1295                             1                             3                          1295                          1296                          1415                          1416
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1296                             1                             3                          1296                          1297                          1416                          1417
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1297                             1                             3                          1297                          1298                          1417                          1418
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1298                             1                             3                          1298                          1299                          1418                          1419
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1299                             1                             3                          1299                          1300                          1419                          1420
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1300                             1                             3                          1300                          1301                          1420                          1421
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1301                             1                             3                          1301                          1302                          1421                          1422
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1302                             1                             3                          1302                          1303                          1422                          1423
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1303                             1                             3                          1303                          1304                          1423                          1424
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1304                             1                             3                          1304                          1305                          1424                          1425
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1305                             1                             3                          1305                          1306                          1425                          1426
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1306                             1                             3                          1306                          1307                          1426                          1427
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1307                             1                             3                          1307                          1308                          1427                          1428
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1308                             1                             3                          1308                          1309                          1428                          1429
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1309                             1                             3                          1309                          1310                          1429                          1430
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1310                             1                             3                          1310                          1311                          1430                          1431
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1311                             1                             3                          1311                          1312                          1431                          1432
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1312                             1                             3                          1312                          1313                          1432                          1433
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1313                             1                             3                          1313                          1314                          1433                          1434
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1314                             1                             3                          1314                          1315                          1434                          1435
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1315                             1                             3                          1315                          1316                          1435                          1436
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1316                             1                             3                          1316                          1317                          1436                          1437
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1317                             1                             3                          1317                          1318                          1437                          1438
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1318                             1                             3                          1318                          1319                          1438                          1439
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1319                             1                             3                          1319                          1320                          1439                          1440
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1320                             1                             3                          1320                          1201                          1440                          1321
  0.2445174559994318236322E-01  0.2087941320775497239248E-01
                          1321                             1                             3                          1321                          1322                          1441                          1442
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1322                             1                             3                          1322                          1323                          1442                          1443
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1323                             1                             3                          1323                          1324                          1443                          1444
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1324                             1                             3                          1324                          1325                          1444                          1445
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1325                             1                             3                          1325                          1326                          1445                          1446
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1326                             1                             3                          1326                          1327                          1446                          1447
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1327                             1                             3                          1327                          1328                          1447                          1448
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1328                             1                             3                          1328                          1329                          1448                          1449
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1329                             1                             3                          1329                          1330                          1449                          1450
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1330                             1                             3                          1330                          1331                          1450                          1451
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1331                             1                             3                          1331                          1332                          1451                          1452
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1332                             1                             3                          1332                          1333                          1452                          1453
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1333                             1                             3                          1333                          1334                          1453                          1454
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1334                             1                             3                          1334                          1335                          1454                          1455
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1335                             1                             3                          1335                          1336                          1455                          1456
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1336                             1                             3                          1336                          1337                          1456                          1457
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1337                             1                             3                          1337                          1338                          1457                          1458
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1338                             1                             3                          1338                          1339                          1458                          1459
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1339                             1                             3                          1339                          1340                          1459                          1460
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1340                             1                             3                          1340                          1341                          1460                          1461
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1341                             1                             3                          1341                          1342                          1461                          1462
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1342                             1                             3                          1342                          1343                          1462                          1463
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1343                             1                             3                          1343                          1344                          1463                          1464
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1344                             1                             3                          1344                          1345                          1464                          1465
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1345                             1                             3                          1345                          1346                          1465                          1466
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1346                             1                             3                          1346                          1347                          1466                          1467
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1347                             1                             3                          1347                          1348                          1467                          1468
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1348                             1                             3                          1348                          1349                          1468                          1469
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1349                             1                             3                          1349                          1350                          1469                          1470
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1350                             1                             3                          1350                          1351                          1470                          1471
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1351                             1                             3                          1351                          1352                          1471                          1472
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1352                             1                             3                          1352                          1353                          1472                          1473
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1353                             1                             3                          1353                          1354                          1473                          1474
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1354                             1                             3                          1354                          1355                          1474                          1475
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1355                             1                             3                          1355                          1356                          1475                          1476
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1356                             1                             3                          1356                          1357                          1476                          1477
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1357                             1                             3                          1357                          1358                          1477                          1478
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1358                             1                             3                          1358                          1359                          1478                          1479
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1359                             1                             3                          1359                          1360                          1479                          1480
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1360                             1                             3                          1360                          1361                          1480                          1481
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1361                             1                             3                          1361                          1362                          1481                          1482
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1362                             1                             3                          1362                          1363                          1482                          1483
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1363                             1                             3                          1363                          1364                          1483                          1484
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1364                             1                             3                          1364                          1365                          1484                          1485
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1365                             1                             3                          1365                          1366                          1485                          1486
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1366                             1                             3                          1366                          1367                          1486                          1487
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1367                             1                             3                          1367                          1368                          1487                          1488
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1368                             1                             3                          1368                          1369                          1488                          1489
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1369                             1                             3                          1369                          1370                          1489                          1490
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1370                             1                             3                          1370                          1371                          1490                          1491
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1371                             1                             3                          1371                          1372                          1491                          1492
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1372                             1                             3                          1372                          1373                          1492                          1493
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1373                             1                             3                          1373                          1374                          1493                          1494
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1374                             1                             3                          1374                          1375                          1494                          1495
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1375                             1                             3                          1375                          1376                          1495                          1496
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1376                             1                             3                          1376                          1377                          1496                          1497
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1377                             1                             3                          1377                          1378                          1497                          1498
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1378                             1                             3                          1378                          1379                          1498                          1499
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1379                             1                             3                          1379                          1380                          1499                          1500
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1380                             1                             3                          1380                          1381                          1500                          1501
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1381                             1                             3                          1381                          1382                          1501                          1502
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1382                             1                             3                          1382                          1383                          1502                          1503
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1383                             1                             3                          1383                          1384                          1503                          1504
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1384                             1                             3                          1384                          1385                          1504                          1505
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1385                             1                             3                          1385                          1386                          1505                          1506
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1386                             1                             3                          1386                          1387                          1506                          1507
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1387                             1                             3                          1387                          1388                          1507                          1508
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1388                             1                             3                          1388                          1389                          1508                          1509
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1389                             1                             3                          1389                          1390                          1509                          1510
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1390                             1                             3                          1390                          1391                          1510                          1511
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1391                             1                             3                          1391                          1392                          1511                          1512
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1392                             1                             3                          1392                          1393                          1512                          1513
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1393                             1                             3                          1393                          1394                          1513                          1514
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1394                             1                             3                          1394                          1395                          1514                          1515
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1395                             1                             3                          1395                          1396                          1515                          1516
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1396                             1                             3                          1396                          1397                          1516                          1517
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1397                             1                             3                          1397                          1398                          1517                          1518
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1398                             1                             3                          1398                          1399                          1518                          1519
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1399                             1                             3                          1399                          1400                          1519                          1520
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1400                             1                             3                          1400                          1401                          1520                          1521
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1401                             1                             3                          1401                          1402                          1521                          1522
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1402                             1                             3                          1402                          1403                          1522                          1523
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1403                             1                             3                          1403                          1404                          1523                          1524
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1404                             1                             3                          1404                          1405                          1524                          1525
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1405                             1                             3                          1405                          1406                          1525                          1526
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1406                             1                             3                          1406                          1407                          1526                          1527
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1407                             1                             3                          1407                          1408                          1527                          1528
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1408                             1                             3                          1408                          1409                          1528                          1529
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1409                             1                             3                          1409                          1410                          1529                          1530
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1410                             1                             3                          1410                          1411                          1530                          1531
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1411                             1                             3                          1411                          1412                          1531                          1532
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1412                             1                             3                          1412                          1413                          1532                          1533
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1413                             1                             3                          1413                          1414                          1533                          1534
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1414                             1                             3                          1414                          1415                          1534                          1535
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1415                             1                             3                          1415                          1416                          1535                          1536
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1416                             1                             3                          1416                          1417                          1536                          1537
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1417                             1                             3                          1417                          1418                          1537                          1538
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1418                             1                             3                          1418                          1419                          1538                          1539
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1419                             1                             3                          1419                          1420                          1539                          1540
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1420                             1                             3                          1420                          1421                          1540                          1541
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1421                             1                             3                          1421                          1422                          1541                          1542
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1422                             1                             3                          1422                          1423                          1542                          1543
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1423                             1                             3                          1423                          1424                          1543                          1544
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1424                             1                             3                          1424                          1425                          1544                          1545
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1425                             1                             3                          1425                          1426                          1545                          1546
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1426                             1                             3                          1426                          1427                          1546                          1547
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1427                             1                             3                          1427                          1428                          1547                          1548
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1428                             1                             3                          1428                          1429                          1548                          1549
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1429                             1                             3                          1429                          1430                          1549                          1550
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1430                             1                             3                          1430                          1431                          1550                          1551
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1431                             1                             3                          1431                          1432                          1551                          1552
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1432                             1                             3                          1432                          1433                          1552                          1553
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1433                             1                             3                          1433                          1434                          1553                          1554
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1434                             1                             3                          1434                          1435                          1554                          1555
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1435                             1                             3                          1435                          1436                          1555                          1556
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1436                             1                             3                          1436                          1437                          1556                          1557
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1437                             1                             3                          1437                          1438                          1557                          1558
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1438                             1                             3                          1438                          1439                          1558                          1559
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1439                             1                             3                          1439                          1440                          1559                          1560
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1440                             1                             3                          1440                          1321                          1560                          1441
  0.2446375819716535560122E-01  0.2087779428297101974588E-01
                          1441                             1                             3                          1441                          1442                          1561                          1562
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1442                             1                             3                          1442                          1443                          1562                          1563
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1443                             1                             3                          1443                          1444                          1563                          1564
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1444                             1                             3                          1444                          1445                          1564                          1565
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1445                             1                             3                          1445                          1446                          1565                          1566
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1446                             1                             3                          1446                          1447                          1566                          1567
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1447                             1                             3                          1447                          1448                          1567                          1568
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1448                             1                             3                          1448                          1449                          1568                          1569
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1449                             1                             3                          1449                          1450                          1569                          1570
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1450                             1                             3                          1450                          1451                          1570                          1571
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1451                             1                             3                          1451                          1452                          1571                          1572
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1452                             1                             3                          1452                          1453                          1572                          1573
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1453                             1                             3                          1453                          1454                          1573                          1574
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1454                             1                             3                          1454                          1455                          1574                          1575
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1455                             1                             3                          1455                          1456                          1575                          1576
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1456                             1                             3                          1456                          1457                          1576                          1577
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1457                             1                             3                          1457                          1458                          1577                          1578
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1458                             1                             3                          1458                          1459                          1578                          1579
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1459                             1                             3                          1459                          1460                          1579                          1580
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1460                             1                             3                          1460                          1461                          1580                          1581
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1461                             1                             3                          1461                          1462                          1581                          1582
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1462                             1                             3                          1462                          1463                          1582                          1583
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1463                             1                             3                          1463                          1464                          1583                          1584
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1464                             1                             3                          1464                          1465                          1584                          1585
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1465                             1                             3                          1465                          1466                          1585                          1586
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1466                             1                             3                          1466                          1467                          1586                          1587
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1467                             1                             3                          1467                          1468                          1587                          1588
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1468                             1                             3                          1468                          1469                          1588                          1589
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
