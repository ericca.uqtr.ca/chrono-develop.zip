                           202                             0                             0                             0                             0                             0                             0
 -0.2693760186913707332934E+00 -0.1226772188959260462271E+00  0.6045539370067403162068E+00 -0.2947042665377970771523E+00  0.9437168922604080023575E+00  0.1501593238755970505238E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           203                             0                             0                             0                             0                             0                             0
 -0.2761901642611594431820E+00 -0.1226772188959260462271E+00  0.5902677837291449014501E+00 -0.3021591163866514384573E+00  0.9437168922604080023575E+00  0.1345299061428180398270E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           204                             0                             0                             0                             0                             0                             0
 -0.2822472917884514265197E+00 -0.1226772188959260462271E+00  0.5756445843037332199543E+00 -0.3087857691003129123608E+00  0.9437168922604080023575E+00  0.1185317512883601459572E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           205                             0                             0                             0                             0                             0                             0
 -0.2875307991077197256047E+00 -0.1226772188959260462271E+00  0.5607244199036851561857E+00 -0.3145660614843057700796E+00  0.9437168922604080023575E+00  0.1022087091426623906010E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           206                             0                             0                             0                             0                             0                             0
 -0.2920262044926547062573E+00 -0.1226772188959260462271E+00  0.5455481856625326031462E+00 -0.3194841501589891219481E+00  0.9437168922604078913352E+00  0.8560552002964461060230E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           207                             0                             0                             0                             0                             0                             0
 -0.2957211863495678438873E+00 -0.1226772188959260462271E+00  0.5301574785834441971843E+00 -0.3235265549851576438734E+00  0.9437168922604081133798E+00  0.6876769213659260360227E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           208                             0                             0                             0                             0                             0                             0
 -0.2986056169900245249593E+00 -0.1226772188959260462271E+00  0.5145944835247279192103E+00 -0.3266821960121669699006E+00  0.9437168922604078913352E+00  0.5174137677937756807367E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           209                             0                             0                             0                             0                             0                             0
 -0.3006715903901334141501E+00 -0.1226772188959260462271E+00  0.4989018575740699068533E+00 -0.3289424238473079853406E+00  0.9437168922604080023575E+00  0.3457324190490955462263E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           210                             0                             0                             0                             0                             0                             0
 -0.3019134438604090253655E+00 -0.1226772188959260462271E+00  0.4831226131284190317139E+00 -0.3303010433631911046959E+00  0.9437168922604081133798E+00  0.1731034417753618548375E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           211                             0                             0                             0                             0                             0                             0
 -0.3023277735668093990640E+00 -0.1226772188959260462271E+00  0.4673000000000000486722E+00 -0.3307543306781596803567E+00  0.9437168922604080023575E+00  0.4050572323691334600871E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           212                             0                             0                             0                             0                             0                             0
 -0.3019134438604090253655E+00 -0.1226772188959260462271E+00  0.4514773868715807880747E+00 -0.3303010433631910491847E+00  0.9437168922604078913352E+00 -0.1731034417753639712001E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           213                             0                             0                             0                             0                             0                             0
 -0.3006715903901334696613E+00 -0.1226772188959260462271E+00  0.4356981424259304125357E+00 -0.3289424238473080408518E+00  0.9437168922604080023575E+00 -0.3457324190490918686125E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           214                             0                             0                             0                             0                             0                             0
 -0.2986056169900245249593E+00 -0.1226772188959260462271E+00  0.4200055164752721781340E+00 -0.3266821960121670254118E+00  0.9437168922604080023575E+00 -0.5174137677937748480694E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           215                             0                             0                             0                             0                             0                             0
 -0.2957211863495678438873E+00 -0.1226772188959260462271E+00  0.4044425214165559001600E+00 -0.3235265549851576438734E+00  0.9437168922604080023575E+00 -0.6876769213659252033555E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           216                             0                             0                             0                             0                             0                             0
 -0.2920262044926547062573E+00 -0.1226772188959260462271E+00  0.3890518143374671611312E+00 -0.3194841501589890664370E+00  0.9437168922604080023575E+00 -0.8560552002964481876912E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           217                             0                             0                             0                             0                             0                             0
 -0.2875307991077197811158E+00 -0.1226772188959260462271E+00  0.3738755800963149411587E+00 -0.3145660614843058255907E+00  0.9437168922604081133798E+00 -0.1022087091426623212120E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           218                             0                             0                             0                             0                             0                             0
 -0.2822472917884514265197E+00 -0.1226772188959260462271E+00  0.3589554156962668773900E+00 -0.3087857691003129123608E+00  0.9437168922604078913352E+00 -0.1185317512883600626905E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           219                             0                             0                             0                             0                             0                             0
 -0.2761901642611595542043E+00 -0.1226772188959260462271E+00  0.3443322162708554179389E+00 -0.3021591163866516049907E+00  0.9437168922604080023575E+00 -0.1345299061428177067601E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           220                             0                             0                             0                             0                             0                             0
 -0.2693760186913707888046E+00 -0.1226772188959260462271E+00  0.3300460629932596701153E+00 -0.2947042665377971326635E+00  0.9437168922604080023575E+00 -0.1501593238755969950127E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           221                             0                             0                             0                             0                             0                             0
 -0.2618235321784464497696E+00 -0.1226772188959260462271E+00  0.3161361132165952936290E+00 -0.2864416527790049626923E+00  0.9437168922604080023575E+00 -0.1653771653390798679339E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           222                             0                             0                             0                             0                             0                             0
 -0.2535534055629516392294E+00 -0.1226772188959260462271E+00  0.3026404931463314018636E+00 -0.2773939223602608361574E+00  0.9437168922604080023575E+00 -0.1801417194875939431498E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           223                             0                             0                             0                             0                             0                             0
 -0.2445883066870898625567E+00 -0.1226772188959260462271E+00  0.2895961933390112652553E+00 -0.2675858744817422585349E+00  0.9437168922604081133798E+00 -0.1944125177044901398027E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           224                             0                             0                             0                             0                             0                             0
 -0.2349528082637236114927E+00 -0.1226772188959260462271E+00  0.2770389673137089725508E+00 -0.2570443923209354553094E+00  0.9437168922604080023575E+00 -0.2081504447238065047543E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           225                             0                             0                             0                             0                             0                             0
 -0.2246733205242756326037E+00 -0.1226772188959260462271E+00  0.2650032335541171457649E+00 -0.2457983693477132081107E+00  0.9437168922604080023575E+00 -0.2213178458424953920503E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           226                             0                             0                             0                             0                             0                             0
 -0.2137780188301220407610E+00 -0.1226772188959260462271E+00  0.2535219811698780079112E+00 -0.2338786301293444835903E+00  0.9437168922604080023575E+00 -0.2338786301293444280791E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           227                             0                             0                             0                             0                             0                             0
 -0.2022967664458827363738E+00 -0.1226772188959260462271E+00  0.2426266794757242217795E+00 -0.2213178458424952532724E+00  0.9437168922604081133798E+00 -0.2457983693477133468885E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           228                             0                             0                             0                             0                             0                             0
 -0.1902610326862913259216E+00 -0.1226772188959260462271E+00  0.2323471917362766037130E+00 -0.2081504447238068378212E+00  0.9437168922604080023575E+00 -0.2570443923209351777537E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           229                             0                             0                             0                             0                             0                             0
 -0.1777038066609887834169E+00 -0.1226772188959260462271E+00  0.2227116933129102138711E+00 -0.1944125177044902230694E+00  0.9437168922604080023575E+00 -0.2675858744817422030238E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           230                             0                             0                             0                             0                             0                             0
 -0.1646595068536688966088E+00 -0.1226772188959260462271E+00  0.2137465944370485204651E+00 -0.1801417194875942762167E+00  0.9437168922604080023575E+00 -0.2773939223602606141128E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           231                             0                             0                             0                             0                             0                             0
 -0.1511638867834045885097E+00 -0.1226772188959260462271E+00  0.2054764678215534878802E+00 -0.1653771653390797014005E+00  0.9437168922604077803129E+00 -0.2864416527790050182034E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           232                             0                             0                             0                             0                             0                             0
 -0.1372539370067403785569E+00 -0.1226772188959260462271E+00  0.1979239813086292598676E+00 -0.1501593238755970782794E+00  0.9437168922604080023575E+00 -0.2947042665377970771523E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           233                             0                             0                             0                             0                             0                             0
 -0.1229677837291446723667E+00 -0.1226772188959260462271E+00  0.1911098357388404389567E+00 -0.1345299061428177900268E+00  0.9437168922604081133798E+00 -0.3021591163866515494796E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           234                             0                             0                             0                             0                             0                             0
 -0.1083445843037334488379E+00 -0.1226772188959260462271E+00  0.1850527082115486776637E+00 -0.1185317512883604373908E+00  0.9437168922604081133798E+00 -0.3087857691003128013385E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           235                             0                             0                             0                             0                             0                             0
 -0.9342441990368516302468E-01 -0.1226772188959260462271E+00  0.1797692008922802675563E+00 -0.1022087091426624183566E+00  0.9437168922604080023575E+00 -0.3145660614843057700796E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           236                             0                             0                             0                             0                             0                             0
 -0.7824818566253267937416E-01 -0.1226772188959260462271E+00  0.1752737955073452869037E+00 -0.8560552002964463835788E-01  0.9437168922604080023575E+00 -0.3194841501589891219481E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           237                             0                             0                             0                             0                             0                             0
 -0.6285747858344389871199E-01 -0.1226772188959260462271E+00  0.1715788136504320937625E+00 -0.6876769213659232604652E-01  0.9437168922604080023575E+00 -0.3235265549851576993845E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           238                             0                             0                             0                             0                             0                             0
 -0.4729448352472792604928E-01 -0.1226772188959260462271E+00  0.1686943830099754682017E+00 -0.5174137677937758889035E-01  0.9437168922604078913352E+00 -0.3266821960121669699006E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           239                             0                             0                             0                             0                             0                             0
 -0.3160185757406965695315E-01 -0.1226772188959260462271E+00  0.1666284096098665234997E+00 -0.3457324190490928400576E-01  0.9437168922604081133798E+00 -0.3289424238473080408518E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           240                             0                             0                             0                             0                             0                             0
 -0.1582261312841931263917E-01 -0.1226772188959260462271E+00  0.1653865561395909677955E+00 -0.1731034417753649773397E-01  0.9437168922604080023575E+00 -0.3303010433631910491847E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           241                             0                             0                             0                             0                             0                             0
  0.2059584268922830958386E-16 -0.1354477621473950677000E+00  0.1309443633614534863163E+00  0.2049810573507234680540E-16  0.9423036116584815324870E+00 -0.3347594710465732203986E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           242                             0                             0                             0                             0                             0                             0
  0.1760349388118253102786E-01 -0.1354477621473950677000E+00  0.1314053270715698218396E+00  0.1751995702860452419625E-01  0.9423036116584815324870E+00 -0.3343006948259266697399E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           243                             0                             0                             0                             0                             0                             0
  0.3515873780924050340246E-01 -0.1354477621473950677000E+00  0.1327869547324305177227E+00  0.3499189307279083199775E-01  0.9423036116584814214647E+00 -0.3329256236377186040087E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           244                             0                             0                             0                             0                             0                             0
  0.5261761408081731816733E-01 -0.1354477621473950677000E+00  0.1350854593986528517924E+00  0.5236791877032135472669E-01  0.9423036116584815324870E+00 -0.3306380264564959814422E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           245                             0                             0                             0                             0                             0                             0
  0.6993226912960412433584E-01 -0.1354477621473950677000E+00  0.1382945410287140242112E+00  0.6960040764255183420861E-01  0.9423036116584814214647E+00 -0.3274441734271234527576E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           246                             0                             0                             0                             0                             0                             0
  0.8705524468963904416441E-01 -0.1354477621473950677000E+00  0.1424054037529263183615E+00  0.8664212663529902158643E-01  0.9423036116584816435093E+00 -0.3233528186787526514934E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           247                             0                             0                             0                             0                             0                             0
  0.1039396078751155944042E+00 -0.1354477621473950677000E+00  0.1474067799823054469854E+00  0.1034463655813593063737E+00  0.9423036116584815324870E+00 -0.3183751763303622195345E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           248                             0                             0                             0                             0                             0                             0
  0.1205390798201600166539E+00 -0.1354477621473950677000E+00  0.1532849612922479454191E+00  0.1199670652298297918170E+00  0.9423036116584816435093E+00 -0.3125248897536374581563E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           249                             0                             0                             0                             0                             0                             0
  0.1368081625259860434340E+00 -0.1354477621473950677000E+00  0.1600238359963706558098E+00  0.1361589434913137164340E+00  0.9423036116584815324870E+00 -0.3058179941774367138763E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           250                             0                             0                             0                             0                             0                             0
  0.1527022635677471595894E+00 -0.1354477621473950677000E+00  0.1676049333075230740597E+00  0.1519776195529801143813E+00  0.9423036116584814214647E+00 -0.2982728727363437304376E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           251                             0                             0                             0                             0                             0                             0
  0.1681778183192732256668E+00 -0.1354477621473950677000E+00  0.1760074739649308273037E+00  0.1673797355232865824437E+00  0.9423036116584815324870E+00 -0.2899102060837737138144E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           252                             0                             0                             0                             0                             0                             0
  0.1831924093606830672432E+00 -0.1354477621473950677000E+00  0.1852084271887055044736E+00  0.1823230752729465276030E+00  0.9423036116584815324870E+00 -0.2807529157077393033859E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           253                             0                             0                             0                             0                             0                             0
  0.1977048827415834875154E+00 -0.1354477621473950677000E+00  0.1951825738056111592122E+00  0.1967666801464048875747E+00  0.9423036116584815324870E+00 -0.2708261011046458888174E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           254                             0                             0                             0                             0                             0                             0
  0.2116754607811871247147E+00 -0.1354477621473950677000E+00  0.2059025753730652774642E+00  0.2106709612266662035029E+00  0.9423036116584815324870E+00 -0.2601569709833161381241E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           255                             0                             0                             0                             0                             0                             0
  0.2250658510961704161790E+00 -0.1354477621473950677000E+00  0.2173390491119095435657E+00  0.2239978078457641741394E+00  0.9423036116584815324870E+00 -0.2487747686878104269592E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           256                             0                             0                             0                             0                             0                             0
  0.2378393515574345751240E+00 -0.1354477621473950677000E+00  0.2294606484425653902814E+00  0.2367106920434536299069E+00  0.9423036116584815324870E+00 -0.2367106920434536576625E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           257                             0                             0                             0                             0                             0                             0
  0.2499609508880904773509E+00 -0.1354477621473950677000E+00  0.2422341489038295769820E+00  0.2487747686878104547148E+00  0.9423036116584815324870E+00 -0.2239978078457641741394E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           258                             0                             0                             0                             0                             0                             0
  0.2613974246269347712079E+00 -0.1354477621473950677000E+00  0.2556245392188128962019E+00  0.2601569709833161381241E+00  0.9423036116584815324870E+00 -0.2106709612266661757474E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           259                             0                             0                             0                             0                             0                             0
  0.2721174261943888339488E+00 -0.1354477621473950677000E+00  0.2695951172584165056456E+00  0.2708261011046458888174E+00  0.9423036116584815324870E+00 -0.1967666801464048875747E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           260                             0                             0                             0                             0                             0                             0
  0.2820915728112944886874E+00 -0.1354477621473950677000E+00  0.2841075906393168981623E+00  0.2807529157077393033859E+00  0.9423036116584815324870E+00 -0.1823230752729465276030E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           261                             0                             0                             0                             0                             0                             0
  0.2912925260350691658573E+00 -0.1354477621473950677000E+00  0.2991221816807267397387E+00  0.2899102060837736583032E+00  0.9423036116584814214647E+00 -0.1673797355232866101993E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           262                             0                             0                             0                             0                             0                             0
  0.2996950666924769746124E+00 -0.1354477621473950677000E+00  0.3145977364322528613272E+00  0.2982728727363437859488E+00  0.9423036116584815324870E+00 -0.1519776195529801143813E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           263                             0                             0                             0                             0                             0                             0
  0.3072761640036293373512E+00 -0.1354477621473950677000E+00  0.3304918374740138942158E+00  0.3058179941774367138763E+00  0.9423036116584815324870E+00 -0.1361589434913137719452E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           264                             0                             0                             0                             0                             0                             0
  0.3140150387077520477419E+00 -0.1354477621473950677000E+00  0.3467609201798400042627E+00  0.3125248897536374581563E+00  0.9423036116584816435093E+00 -0.1199670652298297779392E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           265                             0                             0                             0                             0                             0                             0
  0.3198932200176945461756E+00 -0.1354477621473950677000E+00  0.3633603921248844126346E+00  0.3183751763303622195345E+00  0.9423036116584815324870E+00 -0.1034463655813592786181E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           266                             0                             0                             0                             0                             0                             0
  0.3248945962470736747996E+00 -0.1354477621473950677000E+00  0.3802447553103609489966E+00  0.3233528186787526514934E+00  0.9423036116584815324870E+00 -0.8664212663529900770865E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           267                             0                             0                             0                             0                             0                             0
  0.3290054589712860244610E+00 -0.1354477621473950677000E+00  0.3973677308703959520919E+00  0.3274441734271235082687E+00  0.9423036116584815324870E+00 -0.6960040764255173706410E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           268                             0                             0                             0                             0                             0                             0
  0.3322145406013471413686E+00 -0.1354477621473950677000E+00  0.4146823859191827166271E+00  0.3306380264564959814422E+00  0.9423036116584815324870E+00 -0.5236791877032133391001E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           269                             0                             0                             0                             0                             0                             0
  0.3345130452675694754383E+00 -0.1354477621473950677000E+00  0.4321412621907595452697E+00  0.3329256236377186040087E+00  0.9423036116584814214647E+00 -0.3499189307279080424218E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           270                             0                             0                             0                             0                             0                             0
  0.3358946729284301713214E+00 -0.1354477621473950677000E+00  0.4496965061188175627471E+00  0.3343006948259266697399E+00  0.9423036116584814214647E+00 -0.1751995702860442705173E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           271                             0                             0                             0                             0                             0                             0
  0.3363556366385465068447E+00 -0.1354477621473950677000E+00  0.4672999999999999376499E+00  0.3347594710465732203986E+00  0.9423036116584815324870E+00 -0.7433153449344880767636E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           272                             0                             0                             0                             0                             0                             0
  0.3358946729284301713214E+00 -0.1354477621473950677000E+00  0.4849034938811824235749E+00  0.3343006948259266697399E+00  0.9423036116584814214647E+00  0.1751995702860442705173E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           273                             0                             0                             0                             0                             0                             0
  0.3345130452675694754383E+00 -0.1354477621473950677000E+00  0.5024587378092404410523E+00  0.3329256236377186040087E+00  0.9423036116584814214647E+00  0.3499189307279080424218E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           274                             0                             0                             0                             0                             0                             0
  0.3322145406013471413686E+00 -0.1354477621473950677000E+00  0.5199176140808172696950E+00  0.3306380264564959814422E+00  0.9423036116584815324870E+00  0.5236791877032133391001E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           275                             0                             0                             0                             0                             0                             0
  0.3290054589712859689499E+00 -0.1354477621473950677000E+00  0.5372322691296040897413E+00  0.3274441734271234527576E+00  0.9423036116584814214647E+00  0.6960040764255180645304E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           276                             0                             0                             0                             0                             0                             0
  0.3248945962470736747996E+00 -0.1354477621473950677000E+00  0.5543552446896390373254E+00  0.3233528186787526514934E+00  0.9423036116584815324870E+00  0.8664212663529900770865E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           277                             0                             0                             0                             0                             0                             0
  0.3198932200176945461756E+00 -0.1354477621473950677000E+00  0.5712396078751156291986E+00  0.3183751763303622195345E+00  0.9423036116584815324870E+00  0.1034463655813592786181E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           278                             0                             0                             0                             0                             0                             0
  0.3140150387077520477419E+00 -0.1354477621473950677000E+00  0.5878390798201600375705E+00  0.3125248897536374581563E+00  0.9423036116584816435093E+00  0.1199670652298297779392E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           279                             0                             0                             0                             0                             0                             0
  0.3072761640036293928624E+00 -0.1354477621473950677000E+00  0.6041081625259859810839E+00  0.3058179941774367693874E+00  0.9423036116584815324870E+00  0.1361589434913137164340E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           280                             0                             0                             0                             0                             0                             0
  0.2996950666924769746124E+00 -0.1354477621473950677000E+00  0.6200022635677471249949E+00  0.2982728727363437859488E+00  0.9423036116584815324870E+00  0.1519776195529801143813E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           281                             0                             0                             0                             0                             0                             0
  0.2912925260350691658573E+00 -0.1354477621473950677000E+00  0.6354778183192731910722E+00  0.2899102060837737138144E+00  0.9423036116584815324870E+00  0.1673797355232865546881E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           282                             0                             0                             0                             0                             0                             0
  0.2820915728112945441985E+00 -0.1354477621473950677000E+00  0.6504924093606829771375E+00  0.2807529157077393588970E+00  0.9423036116584815324870E+00  0.1823230752729464720918E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           283                             0                             0                             0                             0                             0                             0
  0.2721174261943888339488E+00 -0.1354477621473950677000E+00  0.6650048827415835361876E+00  0.2708261011046458888174E+00  0.9423036116584815324870E+00  0.1967666801464048875747E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           284                             0                             0                             0                             0                             0                             0
  0.2613974246269348267191E+00 -0.1354477621473950677000E+00  0.6789754607811870901202E+00  0.2601569709833161936352E+00  0.9423036116584815324870E+00  0.2106709612266661479918E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           285                             0                             0                             0                             0                             0                             0
  0.2499609508880905606176E+00 -0.1354477621473950677000E+00  0.6923658510961703260733E+00  0.2487747686878105379815E+00  0.9423036116584815324870E+00  0.2239978078457641186283E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           286                             0                             0                             0                             0                             0                             0
  0.2378393515574346028796E+00 -0.1354477621473950677000E+00  0.7051393515574345682850E+00  0.2367106920434536576625E+00  0.9423036116584815324870E+00  0.2367106920434536299069E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           287                             0                             0                             0                             0                             0                             0
  0.2250658510961704439346E+00 -0.1354477621473950677000E+00  0.7172609508880904982675E+00  0.2239978078457642296506E+00  0.9423036116584816435093E+00  0.2487747686878104269592E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           288                             0                             0                             0                             0                             0                             0
  0.2116754607811870969591E+00 -0.1354477621473950677000E+00  0.7286974246269347643690E+00  0.2106709612266661757474E+00  0.9423036116584815324870E+00  0.2601569709833161381241E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           289                             0                             0                             0                             0                             0                             0
  0.1977048827415834875154E+00 -0.1354477621473950677000E+00  0.7394174261943888826210E+00  0.1967666801464048875747E+00  0.9423036116584815324870E+00  0.2708261011046458888174E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           290                             0                             0                             0                             0                             0                             0
  0.1831924093606830949987E+00 -0.1354477621473950677000E+00  0.7493915728112944263373E+00  0.1823230752729465831141E+00  0.9423036116584815324870E+00  0.2807529157077392478747E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           291                             0                             0                             0                             0                             0                             0
  0.1681778183192732256668E+00 -0.1354477621473950677000E+00  0.7585925260350692145295E+00  0.1673797355232865824437E+00  0.9423036116584815324870E+00  0.2899102060837737138144E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           292                             0                             0                             0                             0                             0                             0
  0.1527022635677471595894E+00 -0.1354477621473950677000E+00  0.7669950666924769677735E+00  0.1519776195529801143813E+00  0.9423036116584814214647E+00  0.2982728727363437304376E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           293                             0                             0                             0                             0                             0                             0
  0.1368081625259859601673E+00 -0.1354477621473950677000E+00  0.7745761640036293860234E+00  0.1361589434913136609229E+00  0.9423036116584814214647E+00  0.3058179941774367693874E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           294                             0                             0                             0                             0                             0                             0
  0.1205390798201599472650E+00 -0.1354477621473950677000E+00  0.7813150387077520964141E+00  0.1199670652298297224281E+00  0.9423036116584815324870E+00  0.3125248897536374581563E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           295                             0                             0                             0                             0                             0                             0
  0.1039396078751155944042E+00 -0.1354477621473950677000E+00  0.7871932200176945393366E+00  0.1034463655813593063737E+00  0.9423036116584815324870E+00  0.3183751763303622195345E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           296                             0                             0                             0                             0                             0                             0
  0.8705524468963897477547E-01 -0.1354477621473950677000E+00  0.7921945962470736679606E+00  0.8664212663529895219749E-01  0.9423036116584815324870E+00  0.3233528186787526514934E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           297                             0                             0                             0                             0                             0                             0
  0.6993226912960405494690E-01 -0.1354477621473950677000E+00  0.7963054589712860176220E+00  0.6960040764255175094188E-01  0.9423036116584815324870E+00  0.3274441734271235082687E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           298                             0                             0                             0                             0                             0                             0
  0.5261761408081731816733E-01 -0.1354477621473950677000E+00  0.7995145406013470790185E+00  0.5236791877032135472669E-01  0.9423036116584815324870E+00  0.3306380264564959814422E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           299                             0                             0                             0                             0                             0                             0
  0.3515873780924042707463E-01 -0.1354477621473950677000E+00  0.8018130452675695796216E+00  0.3499189307279075566992E-01  0.9423036116584815324870E+00  0.3329256236377186595199E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           300                             0                             0                             0                             0                             0                             0
  0.1760349388118245470003E-01 -0.1354477621473950677000E+00  0.8031946729284301644824E+00  0.1751995702860444786841E-01  0.9423036116584815324870E+00  0.3343006948259266697399E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           301                             0                             0                             0                             0                             0                             0
  0.1699677515926552084070E-15 -0.1354477621473950677000E+00  0.8036556366385465555169E+00  0.1691611747219699744841E-15  0.9423036116584815324870E+00  0.3347594710465732203986E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           302                             0                             0                             0                             0                             0                             0
 -0.1760349388118241306667E-01 -0.1354477621473950677000E+00  0.8031946729284301644824E+00 -0.1751995702860440623505E-01  0.9423036116584814214647E+00  0.3343006948259266697399E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           303                             0                             0                             0                             0                             0                             0
 -0.3515873780924038544127E-01 -0.1354477621473950677000E+00  0.8018130452675695796216E+00 -0.3499189307279071403656E-01  0.9423036116584815324870E+00  0.3329256236377186595199E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           304                             0                             0                             0                             0                             0                             0
 -0.5261761408081728347286E-01 -0.1354477621473950677000E+00  0.7995145406013470790185E+00 -0.5236791877032132003222E-01  0.9423036116584815324870E+00  0.3306380264564959814422E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           305                             0                             0                             0                             0                             0                             0
 -0.6993226912960401331354E-01 -0.1354477621473950677000E+00  0.7963054589712860176220E+00 -0.6960040764255172318631E-01  0.9423036116584815324870E+00  0.3274441734271235082687E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           306                             0                             0                             0                             0                             0                             0
 -0.8705524468963893314211E-01 -0.1354477621473950677000E+00  0.7921945962470736679606E+00 -0.8664212663529891056413E-01  0.9423036116584815324870E+00  0.3233528186787527070045E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           307                             0                             0                             0                             0                             0                             0
 -0.1039396078751155527709E+00 -0.1354477621473950677000E+00  0.7871932200176945393366E+00 -0.1034463655813592647403E+00  0.9423036116584816435093E+00  0.3183751763303622750456E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           308                             0                             0                             0                             0                             0                             0
 -0.1205390798201599056316E+00 -0.1354477621473950677000E+00  0.7813150387077520964141E+00 -0.1199670652298296807947E+00  0.9423036116584816435093E+00  0.3125248897536375136674E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           309                             0                             0                             0                             0                             0                             0
 -0.1368081625259860434340E+00 -0.1354477621473950677000E+00  0.7745761640036292750011E+00 -0.1361589434913137441896E+00  0.9423036116584815324870E+00  0.3058179941774367138763E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           310                             0                             0                             0                             0                             0                             0
 -0.1527022635677471040783E+00 -0.1354477621473950677000E+00  0.7669950666924769677735E+00 -0.1519776195529800866257E+00  0.9423036116584814214647E+00  0.2982728727363437859488E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           311                             0                             0                             0                             0                             0                             0
 -0.1681778183192731701556E+00 -0.1354477621473950677000E+00  0.7585925260350692145295E+00 -0.1673797355232865269326E+00  0.9423036116584814214647E+00  0.2899102060837737138144E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           312                             0                             0                             0                             0                             0                             0
 -0.1831924093606830672432E+00 -0.1354477621473950677000E+00  0.7493915728112944263373E+00 -0.1823230752729465276030E+00  0.9423036116584813104424E+00  0.2807529157077392478747E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           313                             0                             0                             0                             0                             0                             0
 -0.1977048827415834320043E+00 -0.1354477621473950677000E+00  0.7394174261943888826210E+00 -0.1967666801464048598191E+00  0.9423036116584814214647E+00  0.2708261011046458888174E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           314                             0                             0                             0                             0                             0                             0
 -0.2116754607811870692036E+00 -0.1354477621473950677000E+00  0.7286974246269348753913E+00 -0.2106709612266661479918E+00  0.9423036116584815324870E+00  0.2601569709833161936352E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           315                             0                             0                             0                             0                             0                             0
 -0.2250658510961704161790E+00 -0.1354477621473950677000E+00  0.7172609508880904982675E+00 -0.2239978078457641741394E+00  0.9423036116584815324870E+00  0.2487747686878104547148E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           316                             0                             0                             0                             0                             0                             0
 -0.2378393515574345751240E+00 -0.1354477621473950677000E+00  0.7051393515574345682850E+00 -0.2367106920434536299069E+00  0.9423036116584815324870E+00  0.2367106920434536576625E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           317                             0                             0                             0                             0                             0                             0
 -0.2499609508880903940842E+00 -0.1354477621473950677000E+00  0.6923658510961704370956E+00 -0.2487747686878103992036E+00  0.9423036116584814214647E+00  0.2239978078457642296506E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           318                             0                             0                             0                             0                             0                             0
 -0.2613974246269347156968E+00 -0.1354477621473950677000E+00  0.6789754607811872011425E+00 -0.2601569709833160826129E+00  0.9423036116584815324870E+00  0.2106709612266662867697E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           319                             0                             0                             0                             0                             0                             0
 -0.2721174261943888339488E+00 -0.1354477621473950677000E+00  0.6650048827415835361876E+00 -0.2708261011046458888174E+00  0.9423036116584815324870E+00  0.1967666801464049430859E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           320                             0                             0                             0                             0                             0                             0
 -0.2820915728112945441985E+00 -0.1354477621473950677000E+00  0.6504924093606829771375E+00 -0.2807529157077393588970E+00  0.9423036116584815324870E+00  0.1823230752729464998474E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           321                             0                             0                             0                             0                             0                             0
 -0.2912925260350691103461E+00 -0.1354477621473950677000E+00  0.6354778183192733020945E+00 -0.2899102060837736027921E+00  0.9423036116584815324870E+00  0.1673797355232867212216E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           322                             0                             0                             0                             0                             0                             0
 -0.2996950666924769191013E+00 -0.1354477621473950677000E+00  0.6200022635677471249949E+00 -0.2982728727363437304376E+00  0.9423036116584815324870E+00  0.1519776195529801421369E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           323                             0                             0                             0                             0                             0                             0
 -0.3072761640036292818401E+00 -0.1354477621473950677000E+00  0.6041081625259862031285E+00 -0.3058179941774366583651E+00  0.9423036116584816435093E+00  0.1361589434913139384786E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           324                             0                             0                             0                             0                             0                             0
 -0.3140150387077521587642E+00 -0.1354477621473950677000E+00  0.5878390798201598155259E+00 -0.3125248897536375691786E+00  0.9423036116584815324870E+00  0.1199670652298296114058E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           325                             0                             0                             0                             0                             0                             0
 -0.3198932200176945461756E+00 -0.1354477621473950677000E+00  0.5712396078751156291986E+00 -0.3183751763303622195345E+00  0.9423036116584816435093E+00  0.1034463655813593202515E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           326                             0                             0                             0                             0                             0                             0
 -0.3248945962470736747996E+00 -0.1354477621473950677000E+00  0.5543552446896389263031E+00 -0.3233528186787526514934E+00  0.9423036116584815324870E+00  0.8664212663529896607528E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           327                             0                             0                             0                             0                             0                             0
 -0.3290054589712859689499E+00 -0.1354477621473950677000E+00  0.5372322691296042007636E+00 -0.3274441734271234527576E+00  0.9423036116584815324870E+00  0.6960040764255191747534E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           328                             0                             0                             0                             0                             0                             0
 -0.3322145406013470858575E+00 -0.1354477621473950677000E+00  0.5199176140808173807173E+00 -0.3306380264564959259310E+00  0.9423036116584813104424E+00  0.5236791877032137554338E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           329                             0                             0                             0                             0                             0                             0
 -0.3345130452675694754383E+00 -0.1354477621473950677000E+00  0.5024587378092407741192E+00 -0.3329256236377186040087E+00  0.9423036116584815324870E+00  0.3499189307279107485904E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           330                             0                             0                             0                             0                             0                             0
 -0.3358946729284302268326E+00 -0.1354477621473950677000E+00  0.4849034938811823125526E+00 -0.3343006948259266697399E+00  0.9423036116584816435093E+00  0.1751995702860432296832E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           331                             0                             0                             0                             0                             0                             0
 -0.3363556366385465068447E+00 -0.1354477621473950677000E+00  0.4673000000000000486722E+00 -0.3347594710465732203986E+00  0.9423036116584815324870E+00  0.4099621147014469361079E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           332                             0                             0                             0                             0                             0                             0
 -0.3358946729284301713214E+00 -0.1354477621473950677000E+00  0.4496965061188174517248E+00 -0.3343006948259266697399E+00  0.9423036116584815324870E+00 -0.1751995702860453460459E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           333                             0                             0                             0                             0                             0                             0
 -0.3345130452675695309495E+00 -0.1354477621473950677000E+00  0.4321412621907596562920E+00 -0.3329256236377186595199E+00  0.9423036116584815324870E+00 -0.3499189307279069321988E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           334                             0                             0                             0                             0                             0                             0
 -0.3322145406013471413686E+00 -0.1354477621473950677000E+00  0.4146823859191827166271E+00 -0.3306380264564959814422E+00  0.9423036116584815324870E+00 -0.5236791877032129227665E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           335                             0                             0                             0                             0                             0                             0
 -0.3290054589712859689499E+00 -0.1354477621473950677000E+00  0.3973677308703958410696E+00 -0.3274441734271234527576E+00  0.9423036116584814214647E+00 -0.6960040764255184808640E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           336                             0                             0                             0                             0                             0                             0
 -0.3248945962470736192884E+00 -0.1354477621473950677000E+00  0.3802447553103607824632E+00 -0.3233528186787526514934E+00  0.9423036116584815324870E+00 -0.8664212663529917424210E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           337                             0                             0                             0                             0                             0                             0
 -0.3198932200176946016867E+00 -0.1354477621473950677000E+00  0.3633603921248844681458E+00 -0.3183751763303622750456E+00  0.9423036116584815324870E+00 -0.1034463655813592508625E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           338                             0                             0                             0                             0                             0                             0
 -0.3140150387077521587642E+00 -0.1354477621473950677000E+00  0.3467609201798402263073E+00 -0.3125248897536375691786E+00  0.9423036116584814214647E+00 -0.1199670652298295281390E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           339                             0                             0                             0                             0                             0                             0
 -0.3072761640036293928624E+00 -0.1354477621473950677000E+00  0.3304918374740141162604E+00 -0.3058179941774368248986E+00  0.9423036116584815324870E+00 -0.1361589434913136054117E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           340                             0                             0                             0                             0                             0                             0
 -0.2996950666924769746124E+00 -0.1354477621473950677000E+00  0.3145977364322528613272E+00 -0.2982728727363437859488E+00  0.9423036116584814214647E+00 -0.1519776195529800866257E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           341                             0                             0                             0                             0                             0                             0
 -0.2912925260350691658573E+00 -0.1354477621473950677000E+00  0.2991221816807266842275E+00 -0.2899102060837736583032E+00  0.9423036116584815324870E+00 -0.1673797355232866379549E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           342                             0                             0                             0                             0                             0                             0
 -0.2820915728112945441985E+00 -0.1354477621473950677000E+00  0.2841075906393170091846E+00 -0.2807529157077393588970E+00  0.9423036116584815324870E+00 -0.1823230752729464165807E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           343                             0                             0                             0                             0                             0                             0
 -0.2721174261943888894599E+00 -0.1354477621473950677000E+00  0.2695951172584165611568E+00 -0.2708261011046459443286E+00  0.9423036116584816435093E+00 -0.1967666801464048598191E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           344                             0                             0                             0                             0                             0                             0
 -0.2613974246269349377414E+00 -0.1354477621473950677000E+00  0.2556245392188131182465E+00 -0.2601569709833163046575E+00  0.9423036116584814214647E+00 -0.2106709612266659814583E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           345                             0                             0                             0                             0                             0                             0
 -0.2499609508880903663286E+00 -0.1354477621473950677000E+00  0.2422341489038294659597E+00 -0.2487747686878103436925E+00  0.9423036116584815324870E+00 -0.2239978078457642851617E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           346                             0                             0                             0                             0                             0                             0
 -0.2378393515574346583907E+00 -0.1354477621473950677000E+00  0.2294606484425654180370E+00 -0.2367106920434536854181E+00  0.9423036116584815324870E+00 -0.2367106920434536299069E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           347                             0                             0                             0                             0                             0                             0
 -0.2250658510961703884234E+00 -0.1354477621473950677000E+00  0.2173390491119094880546E+00 -0.2239978078457641463839E+00  0.9423036116584815324870E+00 -0.2487747686878105102259E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           348                             0                             0                             0                             0                             0                             0
 -0.2116754607811872634926E+00 -0.1354477621473950677000E+00  0.2059025753730653329754E+00 -0.2106709612266663145252E+00  0.9423036116584815324870E+00 -0.2601569709833160271018E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           349                             0                             0                             0                             0                             0                             0
 -0.1977048827415835152710E+00 -0.1354477621473950677000E+00  0.1951825738056111592122E+00 -0.1967666801464049430859E+00  0.9423036116584815324870E+00 -0.2708261011046458888174E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           350                             0                             0                             0                             0                             0                             0
 -0.1831924093606832892878E+00 -0.1354477621473950677000E+00  0.1852084271887056710071E+00 -0.1823230752729467496476E+00  0.9423036116584815324870E+00 -0.2807529157077391368524E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           351                             0                             0                             0                             0                             0                             0
 -0.1681778183192731146445E+00 -0.1354477621473950677000E+00  0.1760074739649307717926E+00 -0.1673797355232864714214E+00  0.9423036116584813104424E+00 -0.2899102060837737138144E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           352                             0                             0                             0                             0                             0                             0
 -0.1527022635677471873450E+00 -0.1354477621473950677000E+00  0.1676049333075230740597E+00 -0.1519776195529801698925E+00  0.9423036116584815324870E+00 -0.2982728727363437304376E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           353                             0                             0                             0                             0                             0                             0
 -0.1368081625259859879229E+00 -0.1354477621473950677000E+00  0.1600238359963706002986E+00 -0.1361589434913136886784E+00  0.9423036116584815324870E+00 -0.3058179941774367693874E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           354                             0                             0                             0                             0                             0                             0
 -0.1205390798201601276762E+00 -0.1354477621473950677000E+00  0.1532849612922479454191E+00 -0.1199670652298299028393E+00  0.9423036116584816435093E+00 -0.3125248897536374581563E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           355                             0                             0                             0                             0                             0                             0
 -0.1039396078751156360376E+00 -0.1354477621473950677000E+00  0.1474067799823054469854E+00 -0.1034463655813593341293E+00  0.9423036116584816435093E+00 -0.3183751763303622195345E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           356                             0                             0                             0                             0                             0                             0
 -0.8705524468963900253105E-01 -0.1354477621473950677000E+00  0.1424054037529263183615E+00 -0.8664212663529897995307E-01  0.9423036116584815324870E+00 -0.3233528186787526514934E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           357                             0                             0                             0                             0                             0                             0
 -0.6993226912960394392460E-01 -0.1354477621473950677000E+00  0.1382945410287139687000E+00 -0.6960040764255165379737E-01  0.9423036116584814214647E+00 -0.3274441734271235082687E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           358                             0                             0                             0                             0                             0                             0
 -0.5261761408081735980069E-01 -0.1354477621473950677000E+00  0.1350854593986529073035E+00 -0.5236791877032138942116E-01  0.9423036116584813104424E+00 -0.3306380264564959259310E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           359                             0                             0                             0                             0                             0                             0
 -0.3515873780924046870799E-01 -0.1354477621473950677000E+00  0.1327869547324304622116E+00 -0.3499189307279079730328E-01  0.9423036116584815324870E+00 -0.3329256236377186595199E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           360                             0                             0                             0                             0                             0                             0
 -0.1760349388118264551961E-01 -0.1354477621473950677000E+00  0.1314053270715698218396E+00 -0.1751995702860463868800E-01  0.9423036116584815324870E+00 -0.3343006948259266697399E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           361                             0                             0                             0                             0                             0                             0
  0.2267905928947921885226E-16 -0.1454899278762296632728E+00  0.9692285443820597423681E-01  0.1339179472829765431407E-16  0.9757911127481381230453E+00 -0.2187046050766889293548E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           362                             0                             0                             0                             0                             0                             0
  0.1938404208350854099341E-01 -0.1454899278762296632728E+00  0.9743044344389856226130E-01  0.1144611464142393335297E-01  0.9757911127481380120230E+00 -0.2184048780164166703166E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           363                             0                             0                             0                             0                             0                             0
  0.3871495385503432445917E-01 -0.1454899278762296632728E+00  0.9895181919479373311432E-01  0.2286085627822533397624E-01  0.9757911127481380120230E+00 -0.2175065183666383683558E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           364                             0                             0                             0                             0                             0                             0
  0.5793975062908698903108E-01 -0.1454899278762296632728E+00  0.1014828117057078871177E+00  0.3421293789700680793020E-01  0.9757911127481382340676E+00 -0.2160119884687098368303E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           365                             0                             0                             0                             0                             0                             0
  0.7700573857400801192075E-01 -0.1454899278762296632728E+00  0.1050164837020957087077E+00  0.4547124423112473140529E-01  0.9757911127481380120230E+00 -0.2139253847251977591615E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           366                             0                             0                             0                             0                             0                             0
  0.9586065914210085969760E-01 -0.1454899278762296632728E+00  0.1095431496346375710438E+00  0.5660491704547254004920E-01  0.9757911127481381230453E+00 -0.2112524263719251227389E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           367                             0                             0                             0                             0                             0                             0
  0.1144528323066779929018E+00 -0.1454899278762296632728E+00  0.1150504022266571890754E+00  0.6758343971675828676382E-01  0.9757911127481381230453E+00 -0.2080004398019431322009E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           368                             0                             0                             0                             0                             0                             0
  0.1327312982134213614760E+00 -0.1454899278762296632728E+00  0.1215231464816041717647E+00  0.7837672087744770865747E-01  0.9757911127481381230453E+00 -0.2041783384843973148115E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           369                             0                             0                             0                             0                             0                             0
  0.1506459568578011054552E+00 -0.1454899278762296632728E+00  0.1289436410573907010324E+00  0.8895517689411107375985E-01  0.9757911127481381230453E+00 -0.1997965985333280680702E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           370                             0                             0                             0                             0                             0                             0
  0.1681477054057057274328E+00 -0.1454899278762296632728E+00  0.1372915468941767747069E+00  0.9928981295410622964770E-01  0.9757911127481380120230E+00 -0.1948672299933702500851E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           371                             0                             0                             0                             0                             0                             0
  0.1851885727808969817065E+00 -0.1454899278762296632728E+00  0.1465439829623195189257E+00  0.1093523025383444369218E+00  0.9757911127481381230453E+00 -0.1894037439210557449698E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           372                             0                             0                             0                             0                             0                             0
  0.2017218511503957034670E+00 -0.1454899278762296632728E+00  0.1566755889776851873307E+00  0.1191150650623104545467E+00  0.9757911127481382340676E+00 -0.1834211153519463843864E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           373                             0                             0                             0                             0                             0                             0
  0.2177022239474051545916E+00 -0.1454899278762296632728E+00  0.1676585949124249630415E+00  0.1285513414725273084738E+00  0.9757911127481382340676E+00 -0.1769357422551027514412E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           374                             0                             0                             0                             0                             0                             0
  0.2330858900808708000785E+00 -0.1454899278762296632728E+00  0.1794628971106911330402E+00  0.1376352675912621559284E+00  0.9757911127481381230453E+00 -0.1699654005873905138202E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           375                             0                             0                             0                             0                             0                             0
  0.2478306839912263193071E+00 -0.1454899278762296632728E+00  0.1920561408006651871183E+00  0.1463419450084395001532E+00  0.9757911127481380120230E+00 -0.1625291955708184077345E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           376                             0                             0                             0                             0                             0                             0
