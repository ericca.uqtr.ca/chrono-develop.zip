  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1597                             0                             0                             0                             0                             0                             0
  0.4442829420928769978971E+00  0.2087723167897390097458E-01  0.6116562785862794671132E+00 -0.9509780448516391704317E+00 -0.1284572727460344884753E-01 -0.3089914974573577111094E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1598                             0                             0                             0                             0                             0                             0
  0.4361190438821173076533E+00  0.2087723167897390097458E-01  0.6347104159403771372894E+00 -0.9335033970016367588229E+00 -0.1284572727460344884753E-01 -0.3583383806923159942137E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1599                             0                             0                             0                             0                             0                             0
  0.4267597736863398272256E+00  0.2087723167897390097458E-01  0.6573056929809374393514E+00 -0.9134700812274784142986E+00 -0.1284572727460345058226E-01 -0.4067030833335918971194E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1600                             0                             0                             0                             0                             0                             0
  0.4162307846145961720552E+00  0.2087723167897390097458E-01  0.6793801776241709111659E+00 -0.8909330074552023193135E+00 -0.1284572727460344884753E-01 -0.4539530410930351922438E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1601                             0                             0                             0                             0                             0                             0
  0.4045609358940711053343E+00  0.2087723167897390097458E-01  0.7008733652420487958423E+00 -0.8659539482374857266578E+00 -0.1284572727460344884753E-01 -0.4999587451207314070523E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1602                             0                             0                             0                             0                             0                             0
  0.3917822137689462302923E+00  0.2087723167897390097458E-01  0.7217263445012838118942E+00 -0.8386013694393710249386E+00 -0.1284572727460344884753E-01 -0.5445940969797580244460E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1603                             0                             0                             0                             0                             0                             0
  0.3779296438283283876558E+00  0.2087723167897390097458E-01  0.7418819588351992511122E+00 -0.8089502425780893402063E+00 -0.1284572727460344884753E-01 -0.5877367542732349070533E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1604                             0                             0                             0                             0                             0                             0
  0.3630411950035446477791E+00  0.2087723167897390097458E-01  0.7612849631059053212567E+00 -0.7770818393313433380953E+00 -0.1284572727460344884753E-01 -0.6292684659763294607870E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1605                             0                             0                             0                             0                             0                             0
  0.3471576754979402434920E+00  0.2087723167897390097458E-01  0.7798821750273823294464E+00 -0.7430835087772864611111E+00 -0.1284572727460344884753E-01 -0.6690753965540977565851E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1606                             0                             0                             0                             0                             0                             0
  0.3303226209344299890702E+00  0.2087723167897390097458E-01  0.7976226209344299267201E+00 -0.7070484379767720817256E+00 -0.1284572727460344884753E-01 -0.7070484379767719707033E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1607                             0                             0                             0                             0                             0                             0
  0.3125821750273825028188E+00  0.2087723167897390097458E-01  0.8144576754979400146084E+00 -0.6690753965540980896520E+00 -0.1284572727460344884753E-01 -0.7430835087772861280442E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1608                             0                             0                             0                             0                             0                             0
  0.2939849631059053836069E+00  0.2087723167897390097458E-01  0.8303411950035446409402E+00 -0.6292684659763295718093E+00 -0.1284572727460344711281E-01 -0.7770818393313432270730E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1609                             0                             0                             0                             0                             0                             0
  0.2745819588351993134623E+00  0.2087723167897390097458E-01  0.8452296438283284363280E+00 -0.5877367542732349070533E+00 -0.1284572727460344884753E-01 -0.8089502425780893402063E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1610                             0                             0                             0                             0                             0                             0
  0.2544263445012839852666E+00  0.2087723167897390097458E-01  0.8590822137689461124310E+00 -0.5445940969797583575129E+00 -0.1284572727460344884753E-01 -0.8386013694393708028940E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1611                             0                             0                             0                             0                             0                             0
  0.2335733652420488026813E+00  0.2087723167897390097458E-01  0.8718609358940710984953E+00 -0.4999587451207314625634E+00 -0.1284572727460344884753E-01 -0.8659539482374857266578E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1612                             0                             0                             0                             0                             0                             0
  0.2120801776241709180049E+00  0.2087723167897390097458E-01  0.8835307846145961097051E+00 -0.4539530410930352477550E+00 -0.1284572727460344711281E-01 -0.8909330074552022082912E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1613                             0                             0                             0                             0                             0                             0
  0.1900056929809373906792E+00  0.2087723167897390097458E-01  0.8940597736863398203866E+00 -0.4067030833335917305860E+00 -0.1284572727460344884753E-01 -0.9134700812274784142986E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1614                             0                             0                             0                             0                             0                             0
  0.1674104159403770608616E+00  0.2087723167897390097458E-01  0.9034190438821172453032E+00 -0.3583383806923158276803E+00 -0.1284572727460344711281E-01 -0.9335033970016367588229E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1615                             0                             0                             0                             0                             0                             0
  0.1443562785862795294634E+00  0.2087723167897390097458E-01  0.9115829420928769355470E+00 -0.3089914974573577666206E+00 -0.1284572727460344884753E-01 -0.9509780448516391704317E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1616                             0                             0                             0                             0                             0                             0
  0.1209064707066586780160E+00  0.2087723167897390097458E-01  0.9185290916410887573917E+00 -0.2587976900056043749743E+00 -0.1284572727460344884753E-01 -0.9658461279823766787445E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1617                             0                             0                             0                             0                             0                             0
  0.9712526659493682379409E-01  0.2087723167897390097458E-01  0.9242384536136618589097E+00 -0.2078945360743528758540E+00 -0.1284572727460345058226E-01 -0.9780668940114557452503E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1618                             0                             0                             0                             0                             0                             0
  0.7307784887857275701872E-01  0.2087723167897390097458E-01  0.9286953790462825208962E+00 -0.1564215576702936150166E+00 -0.1284572727460344884753E-01 -0.9876068466686456215342E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1619                             0                             0                             0                             0                             0                             0
  0.4883012985801131466967E-01  0.2087723167897390097458E-01  0.9318876518161368638360E+00 -0.1045198386493887965365E+00 -0.1284572727460344884753E-01 -0.9944398376068269707062E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1620                             0                             0                             0                             0                             0                             0
  0.2444857084564997298792E-01  0.2087723167897390097458E-01  0.9338065221254547854102E+00 -0.5233163801583134294715E-01 -0.1284572727460344884753E-01 -0.9985471380727934942456E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1621                             0                             0                             0                             0                             0                             0
  0.2360593098356981805542E-15  0.2087723167897390097458E-01  0.9344467304840977650571E+00 -0.5052798558483722020180E-15 -0.1284572727460344884753E-01 -0.9999174902414631471714E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1622                             0                             0                             0                             0                             0                             0
 -0.2444857084564991400732E-01  0.2087723167897390097458E-01  0.9338065221254547854102E+00  0.5233163801583121804706E-01 -0.1284572727460344884753E-01 -0.9985471380727934942456E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1623                             0                             0                             0                             0                             0                             0
 -0.4883012985801125221963E-01  0.2087723167897390097458E-01  0.9318876518161368638360E+00  0.1045198386493886716364E+00 -0.1284572727460344884753E-01 -0.9944398376068269707062E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1624                             0                             0                             0                             0                             0                             0
 -0.7307784887857271538536E-01  0.2087723167897390097458E-01  0.9286953790462825208962E+00  0.1564215576702935039943E+00 -0.1284572727460344884753E-01 -0.9876068466686456215342E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1625                             0                             0                             0                             0                             0                             0
 -0.9712526659493676828294E-01  0.2087723167897390097458E-01  0.9242384536136618589097E+00  0.2078945360743527648317E+00 -0.1284572727460344884753E-01 -0.9780668940114557452503E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1626                             0                             0                             0                             0                             0                             0
 -0.1209064707066586363826E+00  0.2087723167897390097458E-01  0.9185290916410888684140E+00  0.2587976900056042639520E+00 -0.1284572727460345231698E-01 -0.9658461279823767897668E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1627                             0                             0                             0                             0                             0                             0
 -0.1443562785862794739522E+00  0.2087723167897390097458E-01  0.9115829420928770465693E+00  0.3089914974573576555983E+00 -0.1284572727460345231698E-01 -0.9509780448516392814540E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1628                             0                             0                             0                             0                             0                             0
 -0.1674104159403770053505E+00  0.2087723167897390097458E-01  0.9034190438821173563255E+00  0.3583383806923157166580E+00 -0.1284572727460344884753E-01 -0.9335033970016368698452E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1629                             0                             0                             0                             0                             0                             0
 -0.1900056929809375017015E+00  0.2087723167897390097458E-01  0.8940597736863398203866E+00  0.4067030833335920081417E+00 -0.1284572727460344884753E-01 -0.9134700812274783032763E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1630                             0                             0                             0                             0                             0                             0
 -0.2120801776241708624937E+00  0.2087723167897390097458E-01  0.8835307846145961097051E+00  0.4539530410930351367327E+00 -0.1284572727460344711281E-01 -0.8909330074552023193135E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1631                             0                             0                             0                             0                             0                             0
 -0.2335733652420487471701E+00  0.2087723167897390097458E-01  0.8718609358940710984953E+00  0.4999587451207313515411E+00 -0.1284572727460344711281E-01 -0.8659539482374857266578E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1632                             0                             0                             0                             0                             0                             0
 -0.2544263445012839297554E+00  0.2087723167897390097458E-01  0.8590822137689461124310E+00  0.5445940969797582464906E+00 -0.1284572727460344711281E-01 -0.8386013694393708028940E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1633                             0                             0                             0                             0                             0                             0
 -0.2745819588351992579511E+00  0.2087723167897390097458E-01  0.8452296438283284363280E+00  0.5877367542732347960310E+00 -0.1284572727460344884753E-01 -0.8089502425780893402063E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1634                             0                             0                             0                             0                             0                             0
 -0.2939849631059053280957E+00  0.2087723167897390097458E-01  0.8303411950035446409402E+00  0.6292684659763294607870E+00 -0.1284572727460344884753E-01 -0.7770818393313433380953E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1635                             0                             0                             0                             0                             0                             0
 -0.3125821750273824473076E+00  0.2087723167897390097458E-01  0.8144576754979401256307E+00  0.6690753965540979786297E+00 -0.1284572727460344884753E-01 -0.7430835087772862390665E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1636                             0                             0                             0                             0                             0                             0
 -0.3303226209344299335591E+00  0.2087723167897390097458E-01  0.7976226209344299267201E+00  0.7070484379767719707033E+00 -0.1284572727460344884753E-01 -0.7070484379767720817256E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1637                             0                             0                             0                             0                             0                             0
 -0.3471576754979400214474E+00  0.2087723167897390097458E-01  0.7798821750273825514910E+00  0.7430835087772860170219E+00 -0.1284572727460344711281E-01 -0.6690753965540980896520E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1638                             0                             0                             0                             0                             0                             0
 -0.3630411950035444812457E+00  0.2087723167897390097458E-01  0.7612849631059055433013E+00  0.7770818393313430050284E+00 -0.1284572727460344884753E-01 -0.6292684659763299048763E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1639                             0                             0                             0                             0                             0                             0
 -0.3779296438283283321447E+00  0.2087723167897390097458E-01  0.7418819588351993621345E+00  0.8089502425780892291840E+00 -0.1284572727460344884753E-01 -0.5877367542732350180756E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1640                             0                             0                             0                             0                             0                             0
 -0.3917822137689462302923E+00  0.2087723167897390097458E-01  0.7217263445012838118942E+00  0.8386013694393710249386E+00 -0.1284572727460345058226E-01 -0.5445940969797581354683E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1641                             0                             0                             0                             0                             0                             0
 -0.4045609358940709943120E+00  0.2087723167897390097458E-01  0.7008733652420490178869E+00  0.8659539482374855046132E+00 -0.1284572727460344884753E-01 -0.4999587451207319066526E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1642                             0                             0                             0                             0                             0                             0
 -0.4162307846145961165440E+00  0.2087723167897390097458E-01  0.6793801776241709111659E+00  0.8909330074552022082912E+00 -0.1284572727460344884753E-01 -0.4539530410930353032661E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1643                             0                             0                             0                             0                             0                             0
 -0.4267597736863396606921E+00  0.2087723167897390097458E-01  0.6573056929809377724183E+00  0.9134700812274780812317E+00 -0.1284572727460345058226E-01 -0.4067030833335925632532E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1644                             0                             0                             0                             0                             0                             0
 -0.4361190438821174186756E+00  0.2087723167897390097458E-01  0.6347104159403769152448E+00  0.9335033970016369808675E+00 -0.1284572727460345058226E-01 -0.3583383806923154946134E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1645                             0                             0                             0                             0                             0                             0
 -0.4442829420928769978971E+00  0.2087723167897390097458E-01  0.6116562785862795781355E+00  0.9509780448516391704317E+00 -0.1284572727460344884753E-01 -0.3089914974573578221317E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1646                             0                             0                             0                             0                             0                             0
 -0.4512290916410887642307E+00  0.2087723167897390097458E-01  0.5882064707066586572992E+00  0.9658461279823766787445E+00 -0.1284572727460344884753E-01 -0.2587976900056044304854E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1647                             0                             0                             0                             0                             0                             0
 -0.4569384536136619212598E+00  0.2087723167897390097458E-01  0.5644252665949370806331E+00  0.9780668940114556342280E+00 -0.1284572727460344884753E-01 -0.2078945360743533754544E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1648                             0                             0                             0                             0                             0                             0
 -0.4613953790462824722240E+00  0.2087723167897390097458E-01  0.5403778488785727640575E+00  0.9876068466686455105119E+00 -0.1284572727460344711281E-01 -0.1564215576702936705278E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1649                             0                             0                             0                             0                             0                             0
 -0.4645876518161368151638E+00  0.2087723167897390097458E-01  0.5161301298580117657977E+00  0.9944398376068268596839E+00 -0.1284572727460344884753E-01 -0.1045198386493897402261E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1650                             0                             0                             0                             0                             0                             0
 -0.4665065221254548477603E+00  0.2087723167897390097458E-01  0.4917485708456497683905E+00  0.9985471380727936052679E+00 -0.1284572727460344884753E-01 -0.5233163801583096130798E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1651                             0                             0                             0                             0                             0                             0
 -0.4671467304840977163849E+00  0.2087723167897390097458E-01  0.4673000000000000486722E+00  0.9999174902414631471714E+00 -0.1284572727460344884753E-01 -0.1224545753835662725594E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1652                             0                             0                             0                             0                             0                             0
 -0.4665065221254547922491E+00  0.2087723167897390097458E-01  0.4428514291543498848647E+00  0.9985471380727934942456E+00 -0.1284572727460344884753E-01  0.5233163801583159968622E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1653                             0                             0                             0                             0                             0                             0
 -0.4645876518161368706750E+00  0.2087723167897390097458E-01  0.4184698701419887756359E+00  0.9944398376068269707062E+00 -0.1284572727460344884753E-01  0.1045198386493886161253E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1654                             0                             0                             0                             0                             0                             0
 -0.4613953790462825277352E+00  0.2087723167897390097458E-01  0.3942221511214273332868E+00  0.9876068466686456215342E+00 -0.1284572727460344884753E-01  0.1564215576702934207276E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1655                             0                             0                             0                             0                             0                             0
 -0.4569384536136619212598E+00  0.2087723167897390097458E-01  0.3701747334050630167113E+00  0.9780668940114556342280E+00 -0.1284572727460344884753E-01  0.2078945360743531534098E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1656                             0                             0                             0                             0                             0                             0
 -0.4512290916410887087196E+00  0.2087723167897390097458E-01  0.3463935292933409959559E+00  0.9658461279823765677222E+00 -0.1284572727460344884753E-01  0.2587976900056050411081E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1657                             0                             0                             0                             0                             0                             0
 -0.4442829420928770534083E+00  0.2087723167897390097458E-01  0.3229437214137205192088E+00  0.9509780448516392814540E+00 -0.1284572727460345058226E-01  0.3089914974573576000871E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1658                             0                             0                             0                             0                             0                             0
 -0.4361190438821174186756E+00  0.2087723167897390097458E-01  0.2998895840596231820996E+00  0.9335033970016369808675E+00 -0.1284572727460344884753E-01  0.3583383806923152725687E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1659                             0                             0                             0                             0                             0                             0
 -0.4267597736863398827367E+00  0.2087723167897390097458E-01  0.2772943070190626579929E+00  0.9134700812274785253209E+00 -0.1284572727460344884753E-01  0.4067030833335915640525E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1660                             0                             0                             0                             0                             0                             0
 -0.4162307846145961720552E+00  0.2087723167897390097458E-01  0.2552198223758291306673E+00  0.8909330074552023193135E+00 -0.1284572727460344711281E-01  0.4539530410930351367327E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1661                             0                             0                             0                             0                             0                             0
 -0.4045609358940710498231E+00  0.2087723167897390097458E-01  0.2337266347579510794574E+00  0.8659539482374856156355E+00 -0.1284572727460344884753E-01  0.4999587451207316846080E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1662                             0                             0                             0                             0                             0                             0
 -0.3917822137689462858035E+00  0.2087723167897390097458E-01  0.2128736554987162299390E+00  0.8386013694393711359609E+00 -0.1284572727460344884753E-01  0.5445940969797579134237E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1663                             0                             0                             0                             0                             0                             0
 -0.3779296438283284431670E+00  0.2087723167897390097458E-01  0.1927180411648007352099E+00  0.8089502425780894512286E+00 -0.1284572727460344884753E-01  0.5877367542732347960310E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1664                             0                             0                             0                             0                             0                             0
 -0.3630411950035447588014E+00  0.2087723167897390097458E-01  0.1733150368940948871099E+00  0.7770818393313436711622E+00 -0.1284572727460344884753E-01  0.6292684659763290166978E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1665                             0                             0                             0                             0                             0                             0
 -0.3471576754979399659362E+00  0.2087723167897390097458E-01  0.1547178249726173793199E+00  0.7430835087772859059996E+00 -0.1284572727460344884753E-01  0.6690753965540983116966E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1666                             0                             0                             0                             0                             0                             0
 -0.3303226209344300445814E+00  0.2087723167897390097458E-01  0.1369773790655700596020E+00  0.7070484379767721927479E+00 -0.1284572727460344884753E-01  0.7070484379767719707033E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1667                             0                             0                             0                             0                             0                             0
 -0.3125821750273823917965E+00  0.2087723167897390097458E-01  0.1201423245020598051802E+00  0.6690753965540978676074E+00 -0.1284572727460344884753E-01  0.7430835087772863500888E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1668                             0                             0                             0                             0                             0                             0
 -0.2939849631059055501403E+00  0.2087723167897390097458E-01  0.1042588049964555674265E+00  0.6292684659763300158986E+00 -0.1284572727460344884753E-01  0.7770818393313428940061E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1669                             0                             0                             0                             0                             0                             0
 -0.2745819588351993689734E+00  0.2087723167897390097458E-01  0.8937035617167166101638E-01  0.5877367542732350180756E+00 -0.1284572727460344884753E-01  0.8089502425780892291840E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1670                             0                             0                             0                             0                             0                             0
 -0.2544263445012842073112E+00  0.2087723167897390097458E-01  0.7551778623105404042448E-01  0.5445940969797589126244E+00 -0.1284572727460344884753E-01  0.8386013694393704698271E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1671                             0                             0                             0                             0                             0                             0
 -0.2335733652420486639034E+00  0.2087723167897390097458E-01  0.6273906410592883231558E-01  0.4999587451207311850077E+00 -0.1284572727460344884753E-01  0.8659539482374858376801E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1672                             0                             0                             0                             0                             0                             0
 -0.2120801776241709457604E+00  0.2087723167897390097458E-01  0.5106921538540387661698E-01  0.4539530410930353587773E+00 -0.1284572727460344884753E-01  0.8909330074552022082912E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1673                             0                             0                             0                             0                             0                             0
 -0.1900056929809374461904E+00  0.2087723167897390097458E-01  0.4054022631366016593546E-01  0.4067030833335918416083E+00 -0.1284572727460344884753E-01  0.9134700812274784142986E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1674                             0                             0                             0                             0                             0                             0
 -0.1674104159403773106618E+00  0.2087723167897390097458E-01  0.3118095611788274101883E-01  0.3583383806923163827918E+00 -0.1284572727460344884753E-01  0.9335033970016366478006E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1675                             0                             0                             0                             0                             0                             0
 -0.1443562785862795572189E+00  0.2087723167897390097458E-01  0.2301705790712299526390E-01  0.3089914974573578776429E+00 -0.1284572727460344884753E-01  0.9509780448516391704317E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1676                             0                             0                             0                             0                             0                             0
 -0.1209064707066587335271E+00  0.2087723167897390097458E-01  0.1607090835891122893031E-01  0.2587976900056044859966E+00 -0.1284572727460344884753E-01  0.9658461279823766787445E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1677                             0                             0                             0                             0                             0                             0
 -0.9712526659493668501621E-01  0.2087723167897390097458E-01  0.1036154638633807190118E-01  0.2078945360743525705427E+00 -0.1284572727460344884753E-01  0.9780668940114557452503E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1678                             0                             0                             0                             0                             0                             0
 -0.7307784887857281252987E-01  0.2087723167897390097458E-01  0.5904620953717520936976E-02  0.1564215576702937260389E+00 -0.1284572727460344711281E-01  0.9876068466686455105119E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1679                             0                             0                             0                             0                             0                             0
 -0.4883012985801137018083E-01  0.2087723167897390097458E-01  0.2712348183863122486059E-02  0.1045198386493889214366E+00 -0.1284572727460344884753E-01  0.9944398376068269707062E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1680                             0                             0                             0                             0                             0                             0
 -0.2444857084565023666589E-01  0.2087723167897390097458E-01  0.7934778745452009118821E-03  0.5233163801583190499755E-01 -0.1284572727460344884753E-01  0.9985471380727934942456E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1681                             0                             0                             0                             0                             0                             0
  0.2858577616120178179651E-16  0.4175440864445539856931E-01  0.4588474145474363830033E-03 -0.6122590952006831116488E-16 -0.1449217005109632722126E-01  0.9998949829893186702634E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1682                             0                             0                             0                             0                             0                             0
  0.2443257813411777237822E-01  0.4175440864445539856931E-01  0.1098636989300516564327E-02 -0.5233046007726818021899E-01 -0.1449217005109632722126E-01  0.9985246616660558016676E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1683                             0                             0                             0                             0                             0                             0
  0.4879818826985748286829E-01  0.4175440864445539856931E-01  0.3016252094806437522578E-02 -0.1045174860009099732094E+00 -0.1449217005109632548654E-01  0.9944174536517645934808E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1684                             0                             0                             0                             0                             0                             0
  0.7303004596347008325896E-01  0.4175440864445539856931E-01  0.6206436681352844875192E-02 -0.1564180367603448529312E+00 -0.1449217005109632895599E-01  0.9875846165181236813169E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1685                             0                             0                             0                             0                             0                             0
  0.9706173337735307660168E-01  0.4175440864445539856931E-01  0.1066044667473514673262E-01 -0.2078898565535040598995E+00 -0.1449217005109632548654E-01  0.9780448785967713609679E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1686                             0                             0                             0                             0                             0                             0
  0.1208273813267270180294E+00  0.4175440864445539856931E-01  0.1636607394315570118692E-01 -0.2587918647000966854144E+00 -0.1449217005109632722126E-01  0.9658243876462515586923E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1687                             0                             0                             0                             0                             0                             0
  0.1442618498224927658935E+00  0.4175440864445539856931E-01  0.2330767975886527398899E-01 -0.3089845423339484531411E+00 -0.1449217005109632548654E-01  0.9509566391828232490013E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1688                             0                             0                             0                             0                             0                             0
  0.1673009066154133306359E+00  0.4175440864445539856931E-01  0.3146623766282796719196E-01 -0.3583303148145151606485E+00 -0.1449217005109632722126E-01  0.9334823846715804007701E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1689                             0                             0                             0                             0                             0                             0
  0.1898814032522443961959E+00  0.4175440864445539856931E-01  0.4081938561492348682691E-01 -0.4066939288094098547965E+00 -0.1449217005109632722126E-01  0.9134495198295177198489E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1690                             0                             0                             0                             0                             0                             0
  0.2119414481612556244716E+00  0.4175440864445539856931E-01  0.5134148728674448047826E-01 -0.4539428230143864317903E+00 -0.1449217005109632722126E-01  0.8909129533466999539826E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1691                             0                             0                             0                             0                             0                             0
  0.2334205762927262228779E+00  0.4175440864445539856931E-01  0.6300370232899066280652E-01 -0.4999474914946592241094E+00 -0.1449217005109632722126E-01  0.8659344563853591525415E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1692                             0                             0                             0                             0                             0                             0
  0.2542599148494438798807E+00  0.4175440864445539856931E-01  0.7577406542086212448694E-01 -0.5445818386516694253885E+00 -0.1449217005109632722126E-01  0.8385824932694320166249E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1693                             0                             0                             0                             0                             0                             0
  0.2744023446529491594426E+00  0.4175440864445539856931E-01  0.8961757388478092112294E-01 -0.5877235248423547941954E+00 -0.1449217005109632722126E-01  0.8089320338286077882728E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1694                             0                             0                             0                             0                             0                             0
  0.2937926567032338454055E+00  0.4175440864445539856931E-01  0.1044962836262980365731E+00 -0.6292543017036086316907E+00 -0.1449217005109632722126E-01  0.7770643479112354645721E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1695                             0                             0                             0                             0                             0                             0
  0.3123777035027721082905E+00  0.4175440864445539856931E-01  0.1203694131362183505907E+00 -0.6690603362628230188491E+00 -0.1449217005109632722126E-01  0.7430667826293192446130E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1696                             0                             0                             0                             0                             0                             0
  0.3301065447301171906780E+00  0.4175440864445539856931E-01  0.1371934552698827469719E+00 -0.7070325229461547067444E+00 -0.1449217005109632722126E-01  0.7070325229461548177667E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1697                             0                             0                             0                             0                             0                             0
  0.3469305868637816980815E+00  0.4175440864445539856931E-01  0.1549222964972278848705E+00 -0.7430667826293193556353E+00 -0.1449217005109632722126E-01  0.6690603362628230188491E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1698                             0                             0                             0                             0                             0                             0
  0.3628037163737020120990E+00  0.4175440864445539856931E-01  0.1735073432967662032667E+00 -0.7770643479112355755944E+00 -0.1449217005109632722126E-01  0.6292543017036085206684E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1699                             0                             0                             0                             0                             0                             0
  0.3776824261152190720381E+00  0.4175440864445539856931E-01  0.1928976553470508337185E+00 -0.8089320338286077882728E+00 -0.1449217005109632722126E-01  0.5877235248423547941954E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1700                             0                             0                             0                             0                             0                             0
  0.3915259345791378686741E+00  0.4175440864445539856931E-01  0.2130400851505561132804E+00 -0.8385824932694320166249E+00 -0.1449217005109632722126E-01  0.5445818386516694253885E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1701                             0                             0                             0                             0                             0                             0
  0.4042962976710092748434E+00  0.4175440864445539856931E-01  0.2338794237072737147720E+00 -0.8659344563853590415192E+00 -0.1449217005109632548654E-01  0.4999474914946593351317E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1702                             0                             0                             0                             0                             0                             0
  0.4159585127132555681939E+00  0.4175440864445539856931E-01  0.2553585518387443964450E+00 -0.8909129533467000650049E+00 -0.1449217005109632722126E-01  0.4539428230143863762791E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1703                             0                             0                             0                             0                             0                             0
  0.4264806143850765063341E+00  0.4175440864445539856931E-01  0.2774185967477555414540E+00 -0.9134495198295177198489E+00 -0.1449217005109632722126E-01  0.4066939288094099658188E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1704                             0                             0                             0                             0                             0                             0
  0.4358337623371720259691E+00  0.4175440864445539856931E-01  0.2999990933845866902807E+00 -0.9334823846715804007701E+00 -0.1449217005109632722126E-01  0.3583303148145151051374E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1705                             0                             0                             0                             0                             0                             0
  0.4439923202411347191720E+00  0.4175440864445539856931E-01  0.3230381501775072550231E+00 -0.9509566391828232490013E+00 -0.1449217005109632548654E-01  0.3089845423339483976299E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1706                             0                             0                             0                             0                             0                             0
  0.4509339260568442919741E+00  0.4175440864445539856931E-01  0.3464726186732730028872E+00 -0.9658243876462515586923E+00 -0.1449217005109632722126E-01  0.2587918647000966299032E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1707                             0                             0                             0                             0                             0                             0
  0.4566395533252649019396E+00  0.4175440864445539856931E-01  0.3702382666226470275816E+00 -0.9780448785967714719902E+00 -0.1449217005109632722126E-01  0.2078898565535037823437E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1708                             0                             0                             0                             0                             0                             0
  0.4610935633186471482858E+00  0.4175440864445539856931E-01  0.3942699540365299237799E+00 -0.9875846165181236813169E+00 -0.1449217005109632895599E-01  0.1564180367603447974201E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1709                             0                             0                             0                             0                             0                             0
  0.4642837479051935556384E+00  0.4175440864445539856931E-01  0.4185018117301425588650E+00 -0.9944174536517645934808E+00 -0.1449217005109632548654E-01  0.1045174860009099038205E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1710                             0                             0                             0                             0                             0                             0
  0.4662013630106994765967E+00  0.4175440864445539856931E-01  0.4428674218658823491523E+00 -0.9985246616660558016676E+00 -0.1449217005109632722126E-01  0.5233046007726789572434E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1711                             0                             0                             0                             0                             0                             0
  0.4668411525854525567780E+00  0.4175440864445539856931E-01  0.4672999999999998821387E+00 -0.9998949829893186702634E+00 -0.1449217005109632722126E-01  0.2220212864643841644304E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1712                             0                             0                             0                             0                             0                             0
  0.4662013630106994765967E+00  0.4175440864445539856931E-01  0.4917325781341176371697E+00 -0.9985246616660558016676E+00 -0.1449217005109632722126E-01 -0.5233046007726789572434E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1713                             0                             0                             0                             0                             0                             0
  0.4642837479051935556384E+00  0.4175440864445539856931E-01  0.5160981882698574274571E+00 -0.9944174536517645934808E+00 -0.1449217005109632548654E-01 -0.1045174860009099038205E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1714                             0                             0                             0                             0                             0                             0
  0.4610935633186471482858E+00  0.4175440864445539856931E-01  0.5403300459634701180534E+00 -0.9875846165181236813169E+00 -0.1449217005109632895599E-01 -0.1564180367603447974201E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1715                             0                             0                             0                             0                             0                             0
  0.4566395533252648464284E+00  0.4175440864445539856931E-01  0.5643617333773530697627E+00 -0.9780448785967713609679E+00 -0.1449217005109632548654E-01 -0.2078898565535040043883E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1716                             0                             0                             0                             0                             0                             0
  0.4509339260568442919741E+00  0.4175440864445539856931E-01  0.5881273813267269279237E+00 -0.9658243876462515586923E+00 -0.1449217005109632722126E-01 -0.2587918647000966299032E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1717                             0                             0                             0                             0                             0                             0
  0.4439923202411347191720E+00  0.4175440864445539856931E-01  0.6115618498224927312990E+00 -0.9509566391828232490013E+00 -0.1449217005109632548654E-01 -0.3089845423339483976299E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1718                             0                             0                             0                             0                             0                             0
  0.4358337623371720259691E+00  0.4175440864445539856931E-01  0.6346009066154132405302E+00 -0.9334823846715804007701E+00 -0.1449217005109632722126E-01 -0.3583303148145151051374E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1719                             0                             0                             0                             0                             0                             0
  0.4264806143850765618453E+00  0.4175440864445539856931E-01  0.6571814032522443893569E+00 -0.9134495198295178308712E+00 -0.1449217005109632722126E-01 -0.4066939288094097992854E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1720                             0                             0                             0                             0                             0                             0
  0.4159585127132555681939E+00  0.4175440864445539856931E-01  0.6792414481612556453882E+00 -0.8909129533467000650049E+00 -0.1449217005109632722126E-01 -0.4539428230143863762791E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1721                             0                             0                             0                             0                             0                             0
  0.4042962976710093303545E+00  0.4175440864445539856931E-01  0.7007205762927262160389E+00 -0.8659344563853591525415E+00 -0.1449217005109632722126E-01 -0.4999474914946591685982E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1722                             0                             0                             0                             0                             0                             0
  0.3915259345791379241852E+00  0.4175440864445539856931E-01  0.7215599148494438175305E+00 -0.8385824932694321276472E+00 -0.1449217005109632722126E-01 -0.5445818386516692033439E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1723                             0                             0                             0                             0                             0                             0
  0.3776824261152190720381E+00  0.4175440864445539856931E-01  0.7417023446529491526036E+00 -0.8089320338286077882728E+00 -0.1449217005109632722126E-01 -0.5877235248423547941954E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1724                             0                             0                             0                             0                             0                             0
  0.3628037163737020120990E+00  0.4175440864445539856931E-01  0.7610926567032336720331E+00 -0.7770643479112356866167E+00 -0.1449217005109632722126E-01 -0.6292543017036084096461E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1725                             0                             0                             0                             0                             0                             0
  0.3469305868637818091038E+00  0.4175440864445539856931E-01  0.7796777035027719904292E+00 -0.7430667826293195776799E+00 -0.1449217005109632722126E-01 -0.6690603362628227968045E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1726                             0                             0                             0                             0                             0                             0
  0.3301065447301172461891E+00  0.4175440864445539856931E-01  0.7974065447301171838390E+00 -0.7070325229461548177667E+00 -0.1449217005109632722126E-01 -0.7070325229461547067444E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1727                             0                             0                             0                             0                             0                             0
  0.3123777035027721638016E+00  0.4175440864445539856931E-01  0.8142305868637815802202E+00 -0.6690603362628231298714E+00 -0.1449217005109632895599E-01 -0.7430667826293192446130E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1728                             0                             0                             0                             0                             0                             0
  0.2937926567032337898944E+00  0.4175440864445539856931E-01  0.8301037163737019497489E+00 -0.6292543017036085206684E+00 -0.1449217005109632722126E-01 -0.7770643479112355755944E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1729                             0                             0                             0                             0                             0                             0
  0.2744023446529491594426E+00  0.4175440864445539856931E-01  0.8449824261152190096880E+00 -0.5877235248423547941954E+00 -0.1449217005109632722126E-01 -0.8089320338286077882728E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1730                             0                             0                             0                             0                             0                             0
  0.2542599148494439353918E+00  0.4175440864445539856931E-01  0.8588259345791378063240E+00 -0.5445818386516695364108E+00 -0.1449217005109632722126E-01 -0.8385824932694319056026E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1731                             0                             0                             0                             0                             0                             0
  0.2334205762927262228779E+00  0.4175440864445539856931E-01  0.8715962976710093235155E+00 -0.4999474914946592241094E+00 -0.1449217005109632722126E-01 -0.8659344563853591525415E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1732                             0                             0                             0                             0                             0                             0
  0.2119414481612556244716E+00  0.4175440864445539856931E-01  0.8832585127132555058438E+00 -0.4539428230143864317903E+00 -0.1449217005109632722126E-01 -0.8909129533466999539826E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1733                             0                             0                             0                             0                             0                             0
  0.1898814032522442851736E+00  0.4175440864445539856931E-01  0.8937806143850766105174E+00 -0.4066939288094096327519E+00 -0.1449217005109632548654E-01 -0.9134495198295178308712E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1734                             0                             0                             0                             0                             0                             0
  0.1673009066154132473692E+00  0.4175440864445539856931E-01  0.9031337623371720191301E+00 -0.3583303148145149386039E+00 -0.1449217005109632548654E-01 -0.9334823846715804007701E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1735                             0                             0                             0                             0                             0                             0
  0.1442618498224927658935E+00  0.4175440864445539856931E-01  0.9112923202411347123331E+00 -0.3089845423339484531411E+00 -0.1449217005109632548654E-01 -0.9509566391828232490013E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1736                             0                             0                             0                             0                             0                             0
  0.1208273813267269070071E+00  0.4175440864445539856931E-01  0.9182339260568442851351E+00 -0.2587918647000964633698E+00 -0.1449217005109632548654E-01 -0.9658243876462515586923E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1737                             0                             0                             0                             0                             0                             0
  0.9706173337735297945716E-01  0.4175440864445539856931E-01  0.9239395533252648951006E+00 -0.2078898565535038378549E+00 -0.1449217005109632722126E-01 -0.9780448785967714719902E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1738                             0                             0                             0                             0                             0                             0
  0.7303004596347008325896E-01  0.4175440864445539856931E-01  0.9283935633186470859357E+00 -0.1564180367603448529312E+00 -0.1449217005109632895599E-01 -0.9875846165181236813169E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1739                             0                             0                             0                             0                             0                             0
  0.4879818826985737878488E-01  0.4175440864445539856931E-01  0.9315837479051936043106E+00 -0.1045174860009097511648E+00 -0.1449217005109632722126E-01 -0.9944174536517647045031E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1740                             0                             0                             0                             0                             0                             0
  0.2443257813411766829481E-01  0.4175440864445539856931E-01  0.9335013630106994142466E+00 -0.5233046007726795817439E-01 -0.1449217005109632722126E-01 -0.9985246616660558016676E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1741                             0                             0                             0                             0                             0                             0
  0.2359048947383679241454E-15  0.4175440864445539856931E-01  0.9341411525854526054502E+00 -0.5052684824488366523516E-15 -0.1449217005109632722126E-01 -0.9998949829893186702634E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1742                             0                             0                             0                             0                             0                             0
 -0.2443257813411760931421E-01  0.4175440864445539856931E-01  0.9335013630106994142466E+00  0.5233046007726783327429E-01 -0.1449217005109632548654E-01 -0.9985246616660558016676E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1743                             0                             0                             0                             0                             0                             0
 -0.4879818826985731633483E-01  0.4175440864445539856931E-01  0.9315837479051936043106E+00  0.1045174860009096262647E+00 -0.1449217005109632722126E-01 -0.9944174536517647045031E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1744                             0                             0                             0                             0                             0                             0
 -0.7303004596347004162560E-01  0.4175440864445539856931E-01  0.9283935633186470859357E+00  0.1564180367603447419089E+00 -0.1449217005109632895599E-01 -0.9875846165181236813169E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1745                             0                             0                             0                             0                             0                             0
 -0.9706173337735292394601E-01  0.4175440864445539856931E-01  0.9239395533252648951006E+00  0.2078898565535037268326E+00 -0.1449217005109632722126E-01 -0.9780448785967714719902E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1746                             0                             0                             0                             0                             0                             0
 -0.1208273813267268514959E+00  0.4175440864445539856931E-01  0.9182339260568443961574E+00  0.2587918647000963523475E+00 -0.1449217005109632722126E-01 -0.9658243876462516697146E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1747                             0                             0                             0                             0                             0                             0
 -0.1442618498224927381379E+00  0.4175440864445539856931E-01  0.9112923202411347123331E+00  0.3089845423339483421188E+00 -0.1449217005109632895599E-01 -0.9509566391828233600236E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1748                             0                             0                             0                             0                             0                             0
 -0.1673009066154131918580E+00  0.4175440864445539856931E-01  0.9031337623371720191301E+00  0.3583303148145148275816E+00 -0.1449217005109632548654E-01 -0.9334823846715805117924E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1749                             0                             0                             0                             0                             0                             0
 -0.1898814032522444239515E+00  0.4175440864445539856931E-01  0.8937806143850764994951E+00  0.4066939288094099103077E+00 -0.1449217005109632722126E-01 -0.9134495198295177198489E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1750                             0                             0                             0                             0                             0                             0
 -0.2119414481612555689605E+00  0.4175440864445539856931E-01  0.8832585127132555058438E+00  0.4539428230143863207680E+00 -0.1449217005109632722126E-01 -0.8909129533467000650049E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1751                             0                             0                             0                             0                             0                             0
 -0.2334205762927261673667E+00  0.4175440864445539856931E-01  0.8715962976710093235155E+00  0.4999474914946591130871E+00 -0.1449217005109632548654E-01 -0.8659344563853591525415E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1752                             0                             0                             0                             0                             0                             0
 -0.2542599148494438798807E+00  0.4175440864445539856931E-01  0.8588259345791378063240E+00  0.5445818386516694253885E+00 -0.1449217005109632548654E-01 -0.8385824932694319056026E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1753                             0                             0                             0                             0                             0                             0
 -0.2744023446529491039314E+00  0.4175440864445539856931E-01  0.8449824261152190096880E+00  0.5877235248423546831731E+00 -0.1449217005109632548654E-01 -0.8089320338286077882728E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1754                             0                             0                             0                             0                             0                             0
 -0.2937926567032337343832E+00  0.4175440864445539856931E-01  0.8301037163737019497489E+00  0.6292543017036084096461E+00 -0.1449217005109632722126E-01 -0.7770643479112356866167E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1755                             0                             0                             0                             0                             0                             0
 -0.3123777035027721082905E+00  0.4175440864445539856931E-01  0.8142305868637816912425E+00  0.6690603362628230188491E+00 -0.1449217005109632722126E-01 -0.7430667826293193556353E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1756                             0                             0                             0                             0                             0                             0
 -0.3301065447301171906780E+00  0.4175440864445539856931E-01  0.7974065447301172948613E+00  0.7070325229461547067444E+00 -0.1449217005109632722126E-01 -0.7070325229461548177667E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1757                             0                             0                             0                             0                             0                             0
 -0.3469305868637815870592E+00  0.4175440864445539856931E-01  0.7796777035027722124738E+00  0.7430667826293191335907E+00 -0.1449217005109632548654E-01 -0.6690603362628231298714E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1758                             0                             0                             0                             0                             0                             0
 -0.3628037163737019010767E+00  0.4175440864445539856931E-01  0.7610926567032338940777E+00  0.7770643479112353535498E+00 -0.1449217005109632722126E-01 -0.6292543017036088537353E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1759                             0                             0                             0                             0                             0                             0
 -0.3776824261152190165269E+00  0.4175440864445539856931E-01  0.7417023446529491526036E+00  0.8089320338286076772505E+00 -0.1449217005109632722126E-01 -0.5877235248423549052177E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1760                             0                             0                             0                             0                             0                             0
 -0.3915259345791379241852E+00  0.4175440864445539856931E-01  0.7215599148494438175305E+00  0.8385824932694321276472E+00 -0.1449217005109632895599E-01 -0.5445818386516693143662E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1761                             0                             0                             0                             0                             0                             0
 -0.4042962976710092193322E+00  0.4175440864445539856931E-01  0.7007205762927264380835E+00  0.8659344563853589304969E+00 -0.1449217005109632895599E-01 -0.4999474914946596681986E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1762                             0                             0                             0                             0                             0                             0
 -0.4159585127132555126828E+00  0.4175440864445539856931E-01  0.6792414481612556453882E+00  0.8909129533466999539826E+00 -0.1449217005109632722126E-01 -0.4539428230143864873014E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1763                             0                             0                             0                             0                             0                             0
 -0.4264806143850763953118E+00  0.4175440864445539856931E-01  0.6571814032522447224238E+00  0.9134495198295174978043E+00 -0.1449217005109632895599E-01 -0.4066939288094104654192E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1764                             0                             0                             0                             0                             0                             0
 -0.4358337623371721369914E+00  0.4175440864445539856931E-01  0.6346009066154130184856E+00  0.9334823846715806228147E+00 -0.1449217005109632722126E-01 -0.3583303148145146055370E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1765                             0                             0                             0                             0                             0                             0
 -0.4439923202411347191720E+00  0.4175440864445539856931E-01  0.6115618498224928423213E+00  0.9509566391828232490013E+00 -0.1449217005109632722126E-01 -0.3089845423339485086522E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1766                             0                             0                             0                             0                             0                             0
 -0.4509339260568442919741E+00  0.4175440864445539856931E-01  0.5881273813267269279237E+00  0.9658243876462515586923E+00 -0.1449217005109632548654E-01 -0.2587918647000965188809E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1767                             0                             0                             0                             0                             0                             0
 -0.4566395533252648464284E+00  0.4175440864445539856931E-01  0.5643617333773531807850E+00  0.9780448785967713609679E+00 -0.1449217005109632722126E-01 -0.2078898565535043374553E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1768                             0                             0                             0                             0                             0                             0
 -0.4610935633186470927747E+00  0.4175440864445539856931E-01  0.5403300459634701180534E+00  0.9875846165181235702946E+00 -0.1449217005109632548654E-01 -0.1564180367603449084424E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1769                             0                             0                             0                             0                             0                             0
 -0.4642837479051935556384E+00  0.4175440864445539856931E-01  0.5160981882698577605240E+00  0.9944174536517645934808E+00 -0.1449217005109632722126E-01 -0.1045174860009106948544E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1770                             0                             0                             0                             0                             0                             0
 -0.4662013630106995321079E+00  0.4175440864445539856931E-01  0.4917325781341174706363E+00  0.9985246616660559126899E+00 -0.1449217005109632722126E-01 -0.5233046007726757653522E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
