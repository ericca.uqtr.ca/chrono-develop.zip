                          1771                             0                             0                             0                             0                             0                             0
 -0.4668411525854525567780E+00  0.4175440864445539856931E-01  0.4673000000000000486722E+00  0.9998949829893186702634E+00 -0.1449217005109632722126E-01 -0.1224518190401366223298E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1772                             0                             0                             0                             0                             0                             0
 -0.4662013630106994765967E+00  0.4175440864445539856931E-01  0.4428674218658821826189E+00  0.9985246616660558016676E+00 -0.1449217005109632722126E-01  0.5233046007726821491346E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1773                             0                             0                             0                             0                             0                             0
 -0.4642837479051936111496E+00  0.4175440864445539856931E-01  0.4185018117301426698873E+00  0.9944174536517647045031E+00 -0.1449217005109632722126E-01  0.1045174860009095707536E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1774                             0                             0                             0                             0                             0                             0
 -0.4610935633186471482858E+00  0.4175440864445539856931E-01  0.3942699540365299792910E+00  0.9875846165181236813169E+00 -0.1449217005109632895599E-01  0.1564180367603446586422E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1775                             0                             0                             0                             0                             0                             0
 -0.4566395533252648464284E+00  0.4175440864445539856931E-01  0.3702382666226469165593E+00  0.9780448785967713609679E+00 -0.1449217005109632548654E-01  0.2078898565535041154106E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1776                             0                             0                             0                             0                             0                             0
 -0.4509339260568442364630E+00  0.4175440864445539856931E-01  0.3464726186732727808426E+00  0.9658243876462514476700E+00 -0.1449217005109632895599E-01  0.2587918647000971295036E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1777                             0                             0                             0                             0                             0                             0
 -0.4439923202411347746832E+00  0.4175440864445539856931E-01  0.3230381501775072550231E+00  0.9509566391828233600236E+00 -0.1449217005109632722126E-01  0.3089845423339482866076E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1778                             0                             0                             0                             0                             0                             0
 -0.4358337623371721369914E+00  0.4175440864445539856931E-01  0.2999990933845870233476E+00  0.9334823846715806228147E+00 -0.1449217005109632548654E-01  0.3583303148145143834924E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1779                             0                             0                             0                             0                             0                             0
 -0.4264806143850766173564E+00  0.4175440864445539856931E-01  0.2774185967477557634986E+00  0.9134495198295179418935E+00 -0.1449217005109632722126E-01  0.4066939288094094662185E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1780                             0                             0                             0                             0                             0                             0
 -0.4159585127132555681939E+00  0.4175440864445539856931E-01  0.2553585518387444519561E+00  0.8909129533467000650049E+00 -0.1449217005109632722126E-01  0.4539428230143863207680E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1781                             0                             0                             0                             0                             0                             0
 -0.4042962976710092748434E+00  0.4175440864445539856931E-01  0.2338794237072736592609E+00  0.8659344563853590415192E+00 -0.1449217005109632722126E-01  0.4999474914946594461540E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1782                             0                             0                             0                             0                             0                             0
 -0.3915259345791379796964E+00  0.4175440864445539856931E-01  0.2130400851505562243027E+00  0.8385824932694322386695E+00 -0.1449217005109632722126E-01  0.5445818386516690923216E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1783                             0                             0                             0                             0                             0                             0
 -0.3776824261152191275492E+00  0.4175440864445539856931E-01  0.1928976553470508892296E+00  0.8089320338286078992951E+00 -0.1449217005109632895599E-01  0.5877235248423546831731E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1784                             0                             0                             0                             0                             0                             0
 -0.3628037163737021786325E+00  0.4175440864445539856931E-01  0.1735073432967664253113E+00  0.7770643479112360196837E+00 -0.1449217005109632722126E-01  0.6292543017036079655568E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1785                             0                             0                             0                             0                             0                             0
 -0.3469305868637815870592E+00  0.4175440864445539856931E-01  0.1549222964972277183371E+00  0.7430667826293190225684E+00 -0.1449217005109632722126E-01  0.6690603362628233519160E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1786                             0                             0                             0                             0                             0                             0
 -0.3301065447301173017003E+00  0.4175440864445539856931E-01  0.1371934552698828024830E+00  0.7070325229461549287890E+00 -0.1449217005109633069071E-01  0.7070325229461547067444E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1787                             0                             0                             0                             0                             0                             0
 -0.3123777035027720527793E+00  0.4175440864445539856931E-01  0.1203694131362182395684E+00  0.6690603362628229078268E+00 -0.1449217005109632722126E-01  0.7430667826293194666576E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1788                             0                             0                             0                             0                             0                             0
 -0.2937926567032340119390E+00  0.4175440864445539856931E-01  0.1044962836262981475954E+00  0.6292543017036089647576E+00 -0.1449217005109632722126E-01  0.7770643479112352425275E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1789                             0                             0                             0                             0                             0                             0
 -0.2744023446529492149537E+00  0.4175440864445539856931E-01  0.8961757388478097663409E-01  0.5877235248423549052177E+00 -0.1449217005109632722126E-01  0.8089320338286076772505E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1790                             0                             0                             0                             0                             0                             0
 -0.2542599148494442129476E+00  0.4175440864445539856931E-01  0.7577406542086234653155E-01  0.5445818386516700915223E+00 -0.1449217005109632722126E-01  0.8385824932694315725357E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1791                             0                             0                             0                             0                             0                             0
 -0.2334205762927260841000E+00  0.4175440864445539856931E-01  0.6300370232899060729537E-01  0.4999474914946589465536E+00 -0.1449217005109632548654E-01  0.8659344563853592635638E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1792                             0                             0                             0                             0                             0                             0
 -0.2119414481612556799828E+00  0.4175440864445539856931E-01  0.5134148728674448047826E-01  0.4539428230143865428126E+00 -0.1449217005109632722126E-01  0.8909129533466999539826E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1793                             0                             0                             0                             0                             0                             0
 -0.1898814032522443406847E+00  0.4175440864445539856931E-01  0.4081938561492343131576E-01  0.4066939288094097437742E+00 -0.1449217005109632722126E-01  0.9134495198295178308712E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1794                             0                             0                             0                             0                             0                             0
 -0.1673009066154134971693E+00  0.4175440864445539856931E-01  0.3146623766282802270311E-01  0.3583303148145154937154E+00 -0.1449217005109633069071E-01  0.9334823846715802897478E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1795                             0                             0                             0                             0                             0                             0
 -0.1442618498224928214047E+00  0.4175440864445539856931E-01  0.2330767975886527398899E-01  0.3089845423339485641634E+00 -0.1449217005109632722126E-01  0.9509566391828232490013E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1796                             0                             0                             0                             0                             0                             0
 -0.1208273813267269625182E+00  0.4175440864445539856931E-01  0.1636607394315570118692E-01  0.2587918647000965743921E+00 -0.1449217005109632722126E-01  0.9658243876462515586923E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1797                             0                             0                             0                             0                             0                             0
 -0.9706173337735282680150E-01  0.4175440864445539856931E-01  0.1066044667473509122146E-01  0.2078898565535035325436E+00 -0.1449217005109632548654E-01  0.9780448785967714719902E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1798                             0                             0                             0                             0                             0                             0
 -0.7303004596347013877011E-01  0.4175440864445539856931E-01  0.6206436681352900386344E-02  0.1564180367603449639535E+00 -0.1449217005109632548654E-01  0.9875846165181235702946E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1799                             0                             0                             0                             0                             0                             0
 -0.4879818826985743429603E-01  0.4175440864445539856931E-01  0.3016252094806382011427E-02  0.1045174860009098760649E+00 -0.1449217005109632895599E-01  0.9944174536517647045031E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1800                             0                             0                             0                             0                             0                             0
 -0.2443257813411793197278E-01  0.4175440864445539856931E-01  0.1098636989300516564327E-02  0.5233046007726852022479E-01 -0.1449217005109632722126E-01  0.9985246616660558016676E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1801                             0                             0                             0                             0                             0                             0
  0.2857202088189609859734E-16  0.6263164564168170744818E-01  0.6834881732585285085690E-03 -0.6123157930625321031066E-16 -0.4984435425738811993590E-02  0.9999875776245855663049E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1802                             0                             0                             0                             0                             0                             0
  0.2442082134519948585782E-01  0.6263164564168170744818E-01  0.1322969885659053268512E-02 -0.5233530610604784222284E-01 -0.4984435425738811993590E-02  0.9986171294035931511601E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1803                             0                             0                             0                             0                             0                             0
  0.4877470691656213275245E-01  0.6263164564168170744818E-01  0.3239662247936758721067E-02 -0.1045271647758412580931E+00 -0.4984435425738811126228E-02  0.9945095410439311889306E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1804                             0                             0                             0                             0                             0                             0
  0.7299490440655488632249E-01  0.6263164564168170744818E-01  0.6428311739554215531456E-02 -0.1564325217525784350592E+00 -0.4984435425738812860952E-02  0.9876760711597784014870E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1805                             0                             0                             0                             0                             0                             0
  0.9701502793738286944958E-01  0.6263164564168170744818E-01  0.1088017849389538715954E-01 -0.2079091080606830788113E+00 -0.4984435425738811126228E-02  0.9781354498170985456440E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1806                             0                             0                             0                             0                             0                             0
  0.1207692400200662957710E+00  0.6263164564168170744818E-01  0.1658306025363193159095E-01 -0.2588158299551780450187E+00 -0.4984435425738811993590E-02  0.9659138271958316313004E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1807                             0                             0                             0                             0                             0                             0
  0.1441924320104217560612E+00  0.6263164564168170744818E-01  0.2352132581626292795463E-01 -0.3090131556498338927241E+00 -0.4984435425738811993590E-02  0.9510447019140677582527E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1808                             0                             0                             0                             0                             0                             0
  0.1672204025673297567156E+00  0.6263164564168170744818E-01  0.3167595787815413732602E-01 -0.3583634977640946517319E+00 -0.4984435425738811993590E-02  0.9335688292106641972268E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1809                             0                             0                             0                             0                             0                             0
  0.1897900336241482577293E+00  0.6263164564168170744818E-01  0.4102460515964539977674E-01 -0.4067315904405250925890E+00 -0.4984435425738811993590E-02  0.9135341092379678507029E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1810                             0                             0                             0                             0                             0                             0
  0.2118394633909465030186E+00  0.6263164564168170744818E-01  0.5154164366835467525618E-01 -0.4539848600991244764735E+00 -0.4984435425738811126228E-02  0.8909954557708276157157E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1811                             0                             0                             0                             0                             0                             0
  0.2333082559133706768151E+00  0.6263164564168170744818E-01  0.6319824693275988281016E-01 -0.4999937888122926721302E+00 -0.4984435425738811993590E-02  0.8660146456917544588450E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1812                             0                             0                             0                             0                             0                             0
  0.2541375667233944368739E+00  0.6263164564168170744818E-01  0.7596246501355402580558E-01 -0.5446322693044687301978E+00 -0.4984435425738812860952E-02  0.8386601496647799747208E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1813                             0                             0                             0                             0                             0                             0
  0.2742703041279150322218E+00  0.6263164564168170744818E-01  0.8979931207620750477361E-01 -0.5877779506034060963415E+00 -0.4984435425738811993590E-02  0.8090069444621266203654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1814                             0                             0                             0                             0                             0                             0
  0.2936512856931160486695E+00  0.6263164564168170744818E-01  0.1046708622847090097707E+00 -0.6293125733956839162886E+00 -0.4984435425738811126228E-02  0.7771363074580857066564E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1815                             0                             0                             0                             0                             0                             0
  0.3122273894956828499403E+00  0.6263164564168170744818E-01  0.1205363537536457974042E+00 -0.6691222941672647639422E+00 -0.4984435425738811126228E-02  0.7431355938533847904637E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1816                             0                             0                             0                             0                             0                             0
  0.3299476997263017241657E+00  0.6263164564168170744818E-01  0.1373523002736982134842E+00 -0.7070979972406534752594E+00 -0.4984435425738811126228E-02  0.7070979972406535862817E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1817                             0                             0                             0                             0                             0                             0
  0.3467636462463542512680E+00  0.6263164564168170744818E-01  0.1550726105043171432207E+00 -0.7431355938533849014860E+00 -0.4984435425738812860952E-02  0.6691222941672647639422E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1818                             0                             0                             0                             0                             0                             0
  0.3626291377152910389015E+00  0.6263164564168170744818E-01  0.1736487143068840000026E+00 -0.7771363074580858176788E+00 -0.4984435425738811126228E-02  0.6293125733956838052663E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1819                             0                             0                             0                             0                             0                             0
  0.3775006879237924883874E+00  0.6263164564168170744818E-01  0.1930296958720849609392E+00 -0.8090069444621266203654E+00 -0.4984435425738811993590E-02  0.5877779506034060963415E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1820                             0                             0                             0                             0                             0                             0
  0.3913375349864459673555E+00  0.6263164564168170744818E-01  0.2131624332766055562871E+00 -0.8386601496647799747208E+00 -0.4984435425738812860952E-02  0.5446322693044687301978E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1821                             0                             0                             0                             0                             0                             0
  0.4041017530672400548397E+00  0.6263164564168170744818E-01  0.2339917440866292608348E+00 -0.8660146456917543478227E+00 -0.4984435425738811126228E-02  0.4999937888122927831525E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1822                             0                             0                             0                             0                             0                             0
  0.4157583563316453734160E+00  0.6263164564168170744818E-01  0.2554605366090535456536E+00 -0.8909954557708277267380E+00 -0.4984435425738812860952E-02  0.4539848600991244209624E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1823                             0                             0                             0                             0                             0                             0
  0.4262753948403545933843E+00  0.6263164564168170744818E-01  0.2775099663758516799206E+00 -0.9135341092379678507029E+00 -0.4984435425738812860952E-02  0.4067315904405252036113E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1824                             0                             0                             0                             0                             0                             0
  0.4356240421218458558350E+00  0.6263164564168170744818E-01  0.3000795974326702642010E+00 -0.9335688292106641972268E+00 -0.4984435425738811993590E-02  0.3583634977640945962207E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1825                             0                             0                             0                             0                             0                             0
  0.4437786741837370652064E+00  0.6263164564168170744818E-01  0.3231075679895782926110E+00 -0.9510447019140677582527E+00 -0.4984435425738811126228E-02  0.3090131556498338372130E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1826                             0                             0                             0                             0                             0                             0
  0.4507169397463680615701E+00  0.6263164564168170744818E-01  0.3465307599799337112678E+00 -0.9659138271958316313004E+00 -0.4984435425738811993590E-02  0.2588158299551779895076E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1827                             0                             0                             0                             0                             0                             0
  0.4564198215061046060015E+00  0.6263164564168170744818E-01  0.3702849720626172347338E+00 -0.9781354498170986566663E+00 -0.4984435425738811993590E-02  0.2079091080606828012556E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1828                             0                             0                             0                             0                             0                             0
  0.4608716882604457776296E+00  0.6263164564168170744818E-01  0.3943050955934451207163E+00 -0.9876760711597784014870E+00 -0.4984435425738812860952E-02  0.1564325217525783795480E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1829                             0                             0                             0                             0                             0                             0
  0.4640603377520632344400E+00  0.6263164564168170744818E-01  0.4185252930834378881642E+00 -0.9945095410439311889306E+00 -0.4984435425738811126228E-02  0.1045271647758411887041E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1830                             0                             0                             0                             0                             0                             0
  0.4659770301143409398925E+00  0.6263164564168170744818E-01  0.4428791786548006426116E+00 -0.9986171294035931511601E+00 -0.4984435425738811993590E-02  0.5233530610604755772819E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1831                             0                             0                             0                             0                             0                             0
  0.4666165118267414646525E+00  0.6263164564168170744818E-01  0.4672999999999998821387E+00 -0.9999875776245855663049E+00 -0.4984435425738811993590E-02  0.2220418466035901797328E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1832                             0                             0                             0                             0                             0                             0
  0.4659770301143409398925E+00  0.6263164564168170744818E-01  0.4917208213451993437104E+00 -0.9986171294035931511601E+00 -0.4984435425738811993590E-02 -0.5233530610604755772819E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1833                             0                             0                             0                             0                             0                             0
  0.4640603377520632344400E+00  0.6263164564168170744818E-01  0.5160747069165620981579E+00 -0.9945095410439311889306E+00 -0.4984435425738811126228E-02 -0.1045271647758411887041E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1834                             0                             0                             0                             0                             0                             0
  0.4608716882604457776296E+00  0.6263164564168170744818E-01  0.5402949044065548100946E+00 -0.9876760711597784014870E+00 -0.4984435425738812860952E-02 -0.1564325217525783795480E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1835                             0                             0                             0                             0                             0                             0
  0.4564198215061046060015E+00  0.6263164564168170744818E-01  0.5643150279373828626106E+00 -0.9781354498170985456440E+00 -0.4984435425738811126228E-02 -0.2079091080606830233002E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1836                             0                             0                             0                             0                             0                             0
  0.4507169397463680615701E+00  0.6263164564168170744818E-01  0.5880692400200662195431E+00 -0.9659138271958316313004E+00 -0.4984435425738811993590E-02 -0.2588158299551779895076E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1837                             0                             0                             0                             0                             0                             0
  0.4437786741837370652064E+00  0.6263164564168170744818E-01  0.6114924320104216937111E+00 -0.9510447019140677582527E+00 -0.4984435425738811126228E-02 -0.3090131556498338372130E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1838                             0                             0                             0                             0                             0                             0
  0.4356240421218458558350E+00  0.6263164564168170744818E-01  0.6345204025673296666099E+00 -0.9335688292106641972268E+00 -0.4984435425738811993590E-02 -0.3583634977640945962207E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1839                             0                             0                             0                             0                             0                             0
  0.4262753948403546488954E+00  0.6263164564168170744818E-01  0.6570900336241481953792E+00 -0.9135341092379679617252E+00 -0.4984435425738811993590E-02 -0.4067315904405250370779E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1840                             0                             0                             0                             0                             0                             0
  0.4157583563316453734160E+00  0.6263164564168170744818E-01  0.6791394633909464406685E+00 -0.8909954557708277267380E+00 -0.4984435425738812860952E-02 -0.4539848600991244209624E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1841                             0                             0                             0                             0                             0                             0
  0.4041017530672401103509E+00  0.6263164564168170744818E-01  0.7006082559133706144650E+00 -0.8660146456917544588450E+00 -0.4984435425738811993590E-02 -0.4999937888122926166190E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1842                             0                             0                             0                             0                             0                             0
  0.3913375349864459673555E+00  0.6263164564168170744818E-01  0.7214375667233943190126E+00 -0.8386601496647800857431E+00 -0.4984435425738812860952E-02 -0.5446322693044685081531E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1843                             0                             0                             0                             0                             0                             0
  0.3775006879237924883874E+00  0.6263164564168170744818E-01  0.7415703041279150253828E+00 -0.8090069444621266203654E+00 -0.4984435425738811993590E-02 -0.5877779506034060963415E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1844                             0                             0                             0                             0                             0                             0
  0.3626291377152910944126E+00  0.6263164564168170744818E-01  0.7609512856931159863194E+00 -0.7771363074580859287011E+00 -0.4984435425738812860952E-02 -0.6293125733956836942440E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1845                             0                             0                             0                             0                             0                             0
  0.3467636462463543622903E+00  0.6263164564168170744818E-01  0.7795273894956826765679E+00 -0.7431355938533851235306E+00 -0.4984435425738812860952E-02 -0.6691222941672645418976E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1846                             0                             0                             0                             0                             0                             0
  0.3299476997263017796769E+00  0.6263164564168170744818E-01  0.7972476997263017173267E+00 -0.7070979972406535862817E+00 -0.4984435425738811126228E-02 -0.7070979972406534752594E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1847                             0                             0                             0                             0                             0                             0
  0.3122273894956829054514E+00  0.6263164564168170744818E-01  0.8140636462463541889178E+00 -0.6691222941672648749645E+00 -0.4984435425738811993590E-02 -0.7431355938533847904637E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1848                             0                             0                             0                             0                             0                             0
  0.2936512856931159931584E+00  0.6263164564168170744818E-01  0.8299291377152910875736E+00 -0.6293125733956838052663E+00 -0.4984435425738811126228E-02 -0.7771363074580858176788E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1849                             0                             0                             0                             0                             0                             0
  0.2742703041279150322218E+00  0.6263164564168170744818E-01  0.8448006879237924815484E+00 -0.5877779506034060963415E+00 -0.4984435425738811993590E-02 -0.8090069444621266203654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1850                             0                             0                             0                             0                             0                             0
  0.2541375667233944923851E+00  0.6263164564168170744818E-01  0.8586375349864459050053E+00 -0.5446322693044688412201E+00 -0.4984435425738811126228E-02 -0.8386601496647798636985E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1851                             0                             0                             0                             0                             0                             0
  0.2333082559133706768151E+00  0.6263164564168170744818E-01  0.8714017530672401035119E+00 -0.4999937888122926721302E+00 -0.4984435425738811993590E-02 -0.8660146456917544588450E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1852                             0                             0                             0                             0                             0                             0
  0.2118394633909465030186E+00  0.6263164564168170744818E-01  0.8830583563316453110659E+00 -0.4539848600991244764735E+00 -0.4984435425738811126228E-02 -0.8909954557708276157157E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1853                             0                             0                             0                             0                             0                             0
  0.1897900336241481467070E+00  0.6263164564168170744818E-01  0.8935753948403546420565E+00 -0.4067315904405248705444E+00 -0.4984435425738811126228E-02 -0.9135341092379679617252E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1854                             0                             0                             0                             0                             0                             0
  0.1672204025673296456933E+00  0.6263164564168170744818E-01  0.9029240421218458489960E+00 -0.3583634977640944296873E+00 -0.4984435425738811126228E-02 -0.9335688292106641972268E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1855                             0                             0                             0                             0                             0                             0
  0.1441924320104217560612E+00  0.6263164564168170744818E-01  0.9110786741837371138786E+00 -0.3090131556498338927241E+00 -0.4984435425738811993590E-02 -0.9510447019140677582527E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1856                             0                             0                             0                             0                             0                             0
  0.1207692400200661986265E+00  0.6263164564168170744818E-01  0.9180169397463679992200E+00 -0.2588158299551778229741E+00 -0.4984435425738811126228E-02 -0.9659138271958316313004E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1857                             0                             0                             0                             0                             0                             0
  0.9701502793738275842728E-01  0.6263164564168170744818E-01  0.9237198215061046546737E+00 -0.2079091080606828567667E+00 -0.4984435425738811993590E-02 -0.9781354498170986566663E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1858                             0                             0                             0                             0                             0                             0
  0.7299490440655488632249E-01  0.6263164564168170744818E-01  0.9281716882604458263017E+00 -0.1564325217525784350592E+00 -0.4984435425738812860952E-02 -0.9876760711597784014870E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1859                             0                             0                             0                             0                             0                             0
  0.4877470691656202866904E-01  0.6263164564168170744818E-01  0.9313603377520632831121E+00 -0.1045271647758410360485E+00 -0.4984435425738811993590E-02 -0.9945095410439312999529E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1860                             0                             0                             0                             0                             0                             0
  0.2442082134519938524386E-01  0.6263164564168170744818E-01  0.9332770301143409330535E+00 -0.5233530610604762017823E-01 -0.4984435425738811993590E-02 -0.9986171294035931511601E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1861                             0                             0                             0                             0                             0                             0
  0.2357913789220261381256E-15  0.6263164564168170744818E-01  0.9339165118267414023023E+00 -0.5053152725134335697763E-15 -0.4984435425738811993590E-02 -0.9999875776245855663049E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1862                             0                             0                             0                             0                             0                             0
 -0.2442082134519932626326E-01  0.6263164564168170744818E-01  0.9332770301143409330535E+00  0.5233530610604749527814E-01 -0.4984435425738811993590E-02 -0.9986171294035931511601E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1863                             0                             0                             0                             0                             0                             0
 -0.4877470691656196621899E-01  0.6263164564168170744818E-01  0.9313603377520632831121E+00  0.1045271647758409111484E+00 -0.4984435425738811993590E-02 -0.9945095410439312999529E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1864                             0                             0                             0                             0                             0                             0
 -0.7299490440655483081134E-01  0.6263164564168170744818E-01  0.9281716882604458263017E+00  0.1564325217525783240369E+00 -0.4984435425738812860952E-02 -0.9876760711597784014870E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1865                             0                             0                             0                             0                             0                             0
 -0.9701502793738271679391E-01  0.6263164564168170744818E-01  0.9237198215061046546737E+00  0.2079091080606827457444E+00 -0.4984435425738811993590E-02 -0.9781354498170986566663E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1866                             0                             0                             0                             0                             0                             0
 -0.1207692400200661431153E+00  0.6263164564168170744818E-01  0.9180169397463681102423E+00  0.2588158299551777119518E+00 -0.4984435425738812860952E-02 -0.9659138271958317423227E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1867                             0                             0                             0                             0                             0                             0
 -0.1441924320104217283056E+00  0.6263164564168170744818E-01  0.9110786741837371138786E+00  0.3090131556498337817018E+00 -0.4984435425738811993590E-02 -0.9510447019140678692750E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1868                             0                             0                             0                             0                             0                             0
 -0.1672204025673295901822E+00  0.6263164564168170744818E-01  0.9029240421218458489960E+00  0.3583634977640943186650E+00 -0.4984435425738811993590E-02 -0.9335688292106643082491E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1869                             0                             0                             0                             0                             0                             0
 -0.1897900336241482854849E+00  0.6263164564168170744818E-01  0.8935753948403546420565E+00  0.4067315904405251481002E+00 -0.4984435425738812860952E-02 -0.9135341092379678507029E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1870                             0                             0                             0                             0                             0                             0
 -0.2118394633909464475074E+00  0.6263164564168170744818E-01  0.8830583563316454220882E+00  0.4539848600991243654512E+00 -0.4984435425738811993590E-02 -0.8909954557708277267380E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1871                             0                             0                             0                             0                             0                             0
 -0.2333082559133706213039E+00  0.6263164564168170744818E-01  0.8714017530672401035119E+00  0.4999937888122925611079E+00 -0.4984435425738811126228E-02 -0.8660146456917544588450E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1872                             0                             0                             0                             0                             0                             0
 -0.2541375667233944368739E+00  0.6263164564168170744818E-01  0.8586375349864459050053E+00  0.5446322693044687301978E+00 -0.4984435425738811126228E-02 -0.8386601496647798636985E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1873                             0                             0                             0                             0                             0                             0
 -0.2742703041279149767107E+00  0.6263164564168170744818E-01  0.8448006879237924815484E+00  0.5877779506034059853192E+00 -0.4984435425738811126228E-02 -0.8090069444621266203654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1874                             0                             0                             0                             0                             0                             0
 -0.2936512856931159376472E+00  0.6263164564168170744818E-01  0.8299291377152910875736E+00  0.6293125733956836942440E+00 -0.4984435425738812860952E-02 -0.7771363074580859287011E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1875                             0                             0                             0                             0                             0                             0
 -0.3122273894956828499403E+00  0.6263164564168170744818E-01  0.8140636462463541889178E+00  0.6691222941672647639422E+00 -0.4984435425738812860952E-02 -0.7431355938533849014860E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1876                             0                             0                             0                             0                             0                             0
 -0.3299476997263017241657E+00  0.6263164564168170744818E-01  0.7972476997263018283491E+00  0.7070979972406534752594E+00 -0.4984435425738811126228E-02 -0.7070979972406535862817E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1877                             0                             0                             0                             0                             0                             0
 -0.3467636462463541402457E+00  0.6263164564168170744818E-01  0.7795273894956828986125E+00  0.7431355938533846794414E+00 -0.4984435425738811126228E-02 -0.6691222941672648749645E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1878                             0                             0                             0                             0                             0                             0
 -0.3626291377152909278792E+00  0.6263164564168170744818E-01  0.7609512856931162083640E+00  0.7771363074580855956341E+00 -0.4984435425738812860952E-02 -0.6293125733956841383332E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1879                             0                             0                             0                             0                             0                             0
 -0.3775006879237924328763E+00  0.6263164564168170744818E-01  0.7415703041279150253828E+00  0.8090069444621265093431E+00 -0.4984435425738811993590E-02 -0.5877779506034062073638E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1880                             0                             0                             0                             0                             0                             0
 -0.3913375349864459673555E+00  0.6263164564168170744818E-01  0.7214375667233943190126E+00  0.8386601496647800857431E+00 -0.4984435425738812860952E-02 -0.5446322693044686191755E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1881                             0                             0                             0                             0                             0                             0
 -0.4041017530672399993286E+00  0.6263164564168170744818E-01  0.7006082559133708365096E+00  0.8660146456917542368004E+00 -0.4984435425738812860952E-02 -0.4999937888122931162194E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1882                             0                             0                             0                             0                             0                             0
 -0.4157583563316453179048E+00  0.6263164564168170744818E-01  0.6791394633909465516908E+00  0.8909954557708276157157E+00 -0.4984435425738811126228E-02 -0.4539848600991245319847E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1883                             0                             0                             0                             0                             0                             0
 -0.4262753948403544823620E+00  0.6263164564168170744818E-01  0.6570900336241485284461E+00  0.9135341092379676286583E+00 -0.4984435425738811993590E-02 -0.4067315904405257032117E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1884                             0                             0                             0                             0                             0                             0
 -0.4356240421218459668573E+00  0.6263164564168170744818E-01  0.6345204025673294445653E+00  0.9335688292106644192714E+00 -0.4984435425738812860952E-02 -0.3583634977640940966204E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1885                             0                             0                             0                             0                             0                             0
 -0.4437786741837370652064E+00  0.6263164564168170744818E-01  0.6114924320104218047334E+00  0.9510447019140677582527E+00 -0.4984435425738811993590E-02 -0.3090131556498339482353E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1886                             0                             0                             0                             0                             0                             0
 -0.4507169397463680615701E+00  0.6263164564168170744818E-01  0.5880692400200662195431E+00  0.9659138271958316313004E+00 -0.4984435425738811993590E-02 -0.2588158299551778784853E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1887                             0                             0                             0                             0                             0                             0
 -0.4564198215061046060015E+00  0.6263164564168170744818E-01  0.5643150279373829736329E+00  0.9781354498170985456440E+00 -0.4984435425738811993590E-02 -0.2079091080606833563671E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1888                             0                             0                             0                             0                             0                             0
 -0.4608716882604457221184E+00  0.6263164564168170744818E-01  0.5402949044065549211169E+00  0.9876760711597782904647E+00 -0.4984435425738811126228E-02 -0.1564325217525784905703E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1889                             0                             0                             0                             0                             0                             0
 -0.4640603377520632344400E+00  0.6263164564168170744818E-01  0.5160747069165624312248E+00  0.9945095410439311889306E+00 -0.4984435425738811993590E-02 -0.1045271647758419797380E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1890                             0                             0                             0                             0                             0                             0
 -0.4659770301143409954037E+00  0.6263164564168170744818E-01  0.4917208213451991771770E+00  0.9986171294035932621824E+00 -0.4984435425738811993590E-02 -0.5233530610604723853907E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1891                             0                             0                             0                             0                             0                             0
 -0.4666165118267414646525E+00  0.6263164564168170744818E-01  0.4673000000000000486722E+00  0.9999875776245855663049E+00 -0.4984435425738811993590E-02 -0.1224631586125064206213E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1892                             0                             0                             0                             0                             0                             0
 -0.4659770301143409398925E+00  0.6263164564168170744818E-01  0.4428791786548004760782E+00  0.9986171294035931511601E+00 -0.4984435425738811993590E-02  0.5233530610604787691731E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1893                             0                             0                             0                             0                             0                             0
 -0.4640603377520632899511E+00  0.6263164564168170744818E-01  0.4185252930834380546976E+00  0.9945095410439312999529E+00 -0.4984435425738811993590E-02  0.1045271647758408556372E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1894                             0                             0                             0                             0                             0                             0
 -0.4608716882604457776296E+00  0.6263164564168170744818E-01  0.3943050955934451762275E+00  0.9876760711597784014870E+00 -0.4984435425738812860952E-02  0.1564325217525782407701E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1895                             0                             0                             0                             0                             0                             0
 -0.4564198215061046060015E+00  0.6263164564168170744818E-01  0.3702849720626171237114E+00  0.9781354498170985456440E+00 -0.4984435425738811126228E-02  0.2079091080606831343225E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1896                             0                             0                             0                             0                             0                             0
 -0.4507169397463680060589E+00  0.6263164564168170744818E-01  0.3465307599799334892232E+00  0.9659138271958315202781E+00 -0.4984435425738811993590E-02  0.2588158299551784891079E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1897                             0                             0                             0                             0                             0                             0
 -0.4437786741837371207176E+00  0.6263164564168170744818E-01  0.3231075679895782926110E+00  0.9510447019140678692750E+00 -0.4984435425738811993590E-02  0.3090131556498337261907E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1898                             0                             0                             0                             0                             0                             0
 -0.4356240421218459668573E+00  0.6263164564168170744818E-01  0.3000795974326706527791E+00  0.9335688292106644192714E+00 -0.4984435425738811993590E-02  0.3583634977640938745758E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1899                             0                             0                             0                             0                             0                             0
 -0.4262753948403547044066E+00  0.6263164564168170744818E-01  0.2775099663758519019652E+00  0.9135341092379680727475E+00 -0.4984435425738812860952E-02  0.4067315904405247040110E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1900                             0                             0                             0                             0                             0                             0
 -0.4157583563316453734160E+00  0.6263164564168170744818E-01  0.2554605366090535456536E+00  0.8909954557708277267380E+00 -0.4984435425738811993590E-02  0.4539848600991243654512E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1901                             0                             0                             0                             0                             0                             0
 -0.4041017530672400548397E+00  0.6263164564168170744818E-01  0.2339917440866292053236E+00  0.8660146456917543478227E+00 -0.4984435425738811993590E-02  0.4999937888122928941748E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1902                             0                             0                             0                             0                             0                             0
 -0.3913375349864460228666E+00  0.6263164564168170744818E-01  0.2131624332766057228206E+00  0.8386601496647801967654E+00 -0.4984435425738811993590E-02  0.5446322693044683971308E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1903                             0                             0                             0                             0                             0                             0
 -0.3775006879237925438986E+00  0.6263164564168170744818E-01  0.1930296958720850164504E+00  0.8090069444621267313877E+00 -0.4984435425738812860952E-02  0.5877779506034059853192E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1904                             0                             0                             0                             0                             0                             0
 -0.3626291377152912609461E+00  0.6263164564168170744818E-01  0.1736487143068842220472E+00  0.7771363074580862617680E+00 -0.4984435425738811126228E-02  0.6293125733956832501548E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1905                             0                             0                             0                             0                             0                             0
 -0.3467636462463540847345E+00  0.6263164564168170744818E-01  0.1550726105043169766873E+00  0.7431355938533845684191E+00 -0.4984435425738811993590E-02  0.6691222941672650970091E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1906                             0                             0                             0                             0                             0                             0
 -0.3299476997263018351880E+00  0.6263164564168170744818E-01  0.1373523002736982689953E+00  0.7070979972406536973040E+00 -0.4984435425738812860952E-02  0.7070979972406534752594E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1907                             0                             0                             0                             0                             0                             0
 -0.3122273894956827944291E+00  0.6263164564168170744818E-01  0.1205363537536456863819E+00  0.6691222941672646529199E+00 -0.4984435425738812860952E-02  0.7431355938533850125083E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1908                             0                             0                             0                             0                             0                             0
 -0.2936512856931162152030E+00  0.6263164564168170744818E-01  0.1046708622847091207930E+00  0.6293125733956842493555E+00 -0.4984435425738811993590E-02  0.7771363074580854846118E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1909                             0                             0                             0                             0                             0                             0
 -0.2742703041279150322218E+00  0.6263164564168170744818E-01  0.8979931207620756028476E-01  0.5877779506034062073638E+00 -0.4984435425738811993590E-02  0.8090069444621265093431E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1910                             0                             0                             0                             0                             0                             0
 -0.2541375667233947699408E+00  0.6263164564168170744818E-01  0.7596246501355424785018E-01  0.5446322693044693963316E+00 -0.4984435425738811993590E-02  0.8386601496647795306316E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1911                             0                             0                             0                             0                             0                             0
 -0.2333082559133705380372E+00  0.6263164564168170744818E-01  0.6319824693275982729901E-01  0.4999937888122923945744E+00 -0.4984435425738811993590E-02  0.8660146456917545698673E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1912                             0                             0                             0                             0                             0                             0
 -0.2118394633909465585297E+00  0.6263164564168170744818E-01  0.5154164366835467525618E-01  0.4539848600991245874958E+00 -0.4984435425738811126228E-02  0.8909954557708276157157E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1913                             0                             0                             0                             0                             0                             0
 -0.1897900336241482022182E+00  0.6263164564168170744818E-01  0.4102460515964534426558E-01  0.4067315904405249815667E+00 -0.4984435425738811993590E-02  0.9135341092379679617252E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1914                             0                             0                             0                             0                             0                             0
 -0.1672204025673298954935E+00  0.6263164564168170744818E-01  0.3167595787815419283717E-01  0.3583634977640949847988E+00 -0.4984435425738812860952E-02  0.9335688292106640862045E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1915                             0                             0                             0                             0                             0                             0
 -0.1441924320104218115723E+00  0.6263164564168170744818E-01  0.2352132581626292795463E-01  0.3090131556498340037464E+00 -0.4984435425738811993590E-02  0.9510447019140677582527E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1916                             0                             0                             0                             0                             0                             0
 -0.1207692400200662541376E+00  0.6263164564168170744818E-01  0.1658306025363193159095E-01  0.2588158299551779339964E+00 -0.4984435425738811993590E-02  0.9659138271958316313004E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1917                             0                             0                             0                             0                             0                             0
 -0.9701502793738261964940E-01  0.6263164564168170744818E-01  0.1088017849389538715954E-01  0.2079091080606825514554E+00 -0.4984435425738811993590E-02  0.9781354498170986566663E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1918                             0                             0                             0                             0                             0                             0
 -0.7299490440655494183364E-01  0.6263164564168170744818E-01  0.6428311739554271042607E-02  0.1564325217525785460815E+00 -0.4984435425738811126228E-02  0.9876760711597782904647E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1919                             0                             0                             0                             0                             0                             0
 -0.4877470691656208418019E-01  0.6263164564168170744818E-01  0.3239662247936703209916E-02  0.1045271647758411609486E+00 -0.4984435425738812860952E-02  0.9945095410439312999529E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1920                             0                             0                             0                             0                             0                             0
 -0.2442082134519964545238E-01  0.6263164564168170744818E-01  0.1322969885659053268512E-02  0.5233530610604818222864E-01 -0.4984435425738811993590E-02  0.9986171294035931511601E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1921                             0                             0                             0                             0                             0                             0
  0.2855786811015745030862E-16  0.8350873084007624791436E-01  0.9146204760335785444170E-03 -0.6113906976003831256862E-16 -0.5517350488583697143419E-01  0.9984767820828946982559E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1922                             0                             0                             0                             0                             0                             0
  0.2440872481511512093189E-01  0.8350873084007624791436E-01  0.1553785429646070692655E-02 -0.5225623717668587825402E-01 -0.5517350488583696449529E-01  0.9971084043546851738427E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1923                             0                             0                             0                             0                             0                             0
  0.4875054701214154295741E-01  0.8350873084007624791436E-01  0.3469528383773456958750E-02 -0.1043692436395566858209E+00 -0.5517350488583696449529E-01  0.9930070217982948088675E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1924                             0                             0                             0                             0                             0                             0
  0.7295874734841675812724E-01  0.8350873084007624791436E-01  0.6656598420140047434046E-02 -0.1561961812602288557361E+00 -0.5517350488583697837308E-01  0.9861838760182272123345E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1925                             0                             0                             0                             0                             0                             0
  0.9696697282951030616438E-01  0.8350873084007624791436E-01  0.1110626000130693347145E-01 -0.2075949960051301779185E+00 -0.5517350488583696449529E-01  0.9766576687827942526710E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1926                             0                             0                             0                             0                             0                             0
  0.1207094185781697193161E+00  0.8350873084007624791436E-01  0.1680631691417200368477E-01 -0.2584248072957324726673E+00 -0.5517350488583697143419E-01  0.9644545107638700098818E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1927                             0                             0                             0                             0                             0                             0
  0.1441210082009152515514E+00  0.8350873084007624791436E-01  0.2374114569894347770429E-01 -0.3085462941524255153780E+00 -0.5517350488583696449529E-01  0.9496078499693529906267E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1928                             0                             0                             0                             0                             0                             0
  0.1671375721579105577685E+00  0.8350873084007624791436E-01  0.3189173847195614364125E-01 -0.3578220770636366676598E+00 -0.5517350488583697143419E-01  0.9321583800645023565323E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1929                             0                             0                             0                             0                             0                             0
  0.1896960236472111371864E+00  0.8350873084007624791436E-01  0.4123575502496001909947E-01 -0.4061170945335239035323E+00 -0.5517350488583697143419E-01  0.9121539288334294948157E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1930                             0                             0                             0                             0                             0                             0
  0.2117345315213036982538E+00  0.8350873084007624791436E-01  0.5174758405807794447995E-01 -0.4532989732761479317880E+00 -0.5517350488583697143419E-01  0.8896493270864663793773E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1931                             0                             0                             0                             0                             0                             0
  0.2331926897619831517972E+00  0.8350873084007624791436E-01  0.6339841337859830616708E-01 -0.4992383910414472381056E+00 -0.5517350488583697143419E-01  0.8647062583727258555655E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1932                             0                             0                             0                             0                             0                             0
  0.2540116830490502519702E+00  0.8350873084007624791436E-01  0.7615630887319291275617E-01 -0.5438094310785372975658E+00 -0.5517350488583697143419E-01  0.8373930899097806745957E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1933                             0                             0                             0                             0                             0                             0
  0.2741344479690154267715E+00  0.8350873084007624791436E-01  0.8998630203710150654572E-01 -0.5868899272647709608464E+00 -0.5517350488583697143419E-01  0.8077846851938728089948E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1934                             0                             0                             0                             0                             0                             0
  0.2935058294219494157140E+00  0.8350873084007624791436E-01  0.1048504858203728740129E+00 -0.6283617989545906556970E+00 -0.5517350488583696449529E-01  0.7759621988042735285518E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1935                             0                             0                             0                             0                             0                             0
  0.3120727317977778914049E+00  0.8350873084007624791436E-01  0.1207081185284537561131E+00 -0.6681113746303688483152E+00 -0.5517350488583696449529E-01  0.7420128539642228959750E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1936                             0                             0                             0                             0                             0                             0
  0.3297842645076581868935E+00  0.8350873084007624791436E-01  0.1375157354923417507564E+00 -0.7060297034681374261922E+00 -0.5517350488583697143419E-01  0.7060297034681375372145E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1937                             0                             0                             0                             0                             0                             0
  0.3465918814715462925591E+00  0.8350873084007624791436E-01  0.1552272682022221017561E+00 -0.7420128539642230069973E+00 -0.5517350488583697143419E-01  0.6681113746303688483152E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1938                             0                             0                             0                             0                             0                             0
  0.3624495141796271746593E+00  0.8350873084007624791436E-01  0.1737941705780506329582E+00 -0.7759621988042736395741E+00 -0.5517350488583697143419E-01  0.6283617989545905446747E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1939                             0                             0                             0                             0                             0                             0
  0.3773136979628984866153E+00  0.8350873084007624791436E-01  0.1931655520309845663895E+00 -0.8077846851938728089948E+00 -0.5517350488583697143419E-01  0.5868899272647709608464E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1940                             0                             0                             0                             0                             0                             0
  0.3911436911268070804049E+00  0.8350873084007624791436E-01  0.2132883169509497411909E+00 -0.8373930899097806745957E+00 -0.5517350488583697143419E-01  0.5438094310785372975658E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1941                             0                             0                             0                             0                             0                             0
  0.4039015866214016314828E+00  0.8350873084007624791436E-01  0.2341073102380167858527E+00 -0.8647062583727257445432E+00 -0.5517350488583697143419E-01  0.4992383910414473491279E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1942                             0                             0                             0                             0                             0                             0
  0.4155524159419221041922E+00  0.8350873084007624791436E-01  0.2555654684786963226628E+00 -0.8896493270864664903996E+00 -0.5517350488583697837308E-01  0.4532989732761478762768E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1943                             0                             0                             0                             0                             0                             0
  0.4260642449750399740616E+00  0.8350873084007624791436E-01  0.2776039763527887727079E+00 -0.9121539288334294948157E+00 -0.5517350488583697837308E-01  0.4061170945335240145546E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1944                             0                             0                             0                             0                             0                             0
  0.4354082615280438495198E+00  0.8350873084007624791436E-01  0.3001624278420894631481E+00 -0.9321583800645023565323E+00 -0.5517350488583697143419E-01  0.3578220770636366121487E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1945                             0                             0                             0                             0                             0                             0
