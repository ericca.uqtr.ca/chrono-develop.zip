                          1469                             1                             3                          1469                          1470                          1589                          1590
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1470                             1                             3                          1470                          1471                          1590                          1591
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1471                             1                             3                          1471                          1472                          1591                          1592
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1472                             1                             3                          1472                          1473                          1592                          1593
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1473                             1                             3                          1473                          1474                          1593                          1594
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1474                             1                             3                          1474                          1475                          1594                          1595
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1475                             1                             3                          1475                          1476                          1595                          1596
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1476                             1                             3                          1476                          1477                          1596                          1597
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1477                             1                             3                          1477                          1478                          1597                          1598
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1478                             1                             3                          1478                          1479                          1598                          1599
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1479                             1                             3                          1479                          1480                          1599                          1600
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1480                             1                             3                          1480                          1481                          1600                          1601
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1481                             1                             3                          1481                          1482                          1601                          1602
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1482                             1                             3                          1482                          1483                          1602                          1603
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1483                             1                             3                          1483                          1484                          1603                          1604
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1484                             1                             3                          1484                          1485                          1604                          1605
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1485                             1                             3                          1485                          1486                          1605                          1606
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1486                             1                             3                          1486                          1487                          1606                          1607
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1487                             1                             3                          1487                          1488                          1607                          1608
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1488                             1                             3                          1488                          1489                          1608                          1609
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1489                             1                             3                          1489                          1490                          1609                          1610
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1490                             1                             3                          1490                          1491                          1610                          1611
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1491                             1                             3                          1491                          1492                          1611                          1612
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1492                             1                             3                          1492                          1493                          1612                          1613
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1493                             1                             3                          1493                          1494                          1613                          1614
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1494                             1                             3                          1494                          1495                          1614                          1615
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1495                             1                             3                          1495                          1496                          1615                          1616
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1496                             1                             3                          1496                          1497                          1616                          1617
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1497                             1                             3                          1497                          1498                          1617                          1618
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1498                             1                             3                          1498                          1499                          1618                          1619
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1499                             1                             3                          1499                          1500                          1619                          1620
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1500                             1                             3                          1500                          1501                          1620                          1621
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1501                             1                             3                          1501                          1502                          1621                          1622
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1502                             1                             3                          1502                          1503                          1622                          1623
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1503                             1                             3                          1503                          1504                          1623                          1624
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1504                             1                             3                          1504                          1505                          1624                          1625
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1505                             1                             3                          1505                          1506                          1625                          1626
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1506                             1                             3                          1506                          1507                          1626                          1627
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1507                             1                             3                          1507                          1508                          1627                          1628
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1508                             1                             3                          1508                          1509                          1628                          1629
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1509                             1                             3                          1509                          1510                          1629                          1630
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1510                             1                             3                          1510                          1511                          1630                          1631
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1511                             1                             3                          1511                          1512                          1631                          1632
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1512                             1                             3                          1512                          1513                          1632                          1633
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1513                             1                             3                          1513                          1514                          1633                          1634
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1514                             1                             3                          1514                          1515                          1634                          1635
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1515                             1                             3                          1515                          1516                          1635                          1636
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1516                             1                             3                          1516                          1517                          1636                          1637
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1517                             1                             3                          1517                          1518                          1637                          1638
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1518                             1                             3                          1518                          1519                          1638                          1639
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1519                             1                             3                          1519                          1520                          1639                          1640
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1520                             1                             3                          1520                          1521                          1640                          1641
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1521                             1                             3                          1521                          1522                          1641                          1642
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1522                             1                             3                          1522                          1523                          1642                          1643
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1523                             1                             3                          1523                          1524                          1643                          1644
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1524                             1                             3                          1524                          1525                          1644                          1645
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1525                             1                             3                          1525                          1526                          1645                          1646
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1526                             1                             3                          1526                          1527                          1646                          1647
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1527                             1                             3                          1527                          1528                          1647                          1648
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1528                             1                             3                          1528                          1529                          1648                          1649
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1529                             1                             3                          1529                          1530                          1649                          1650
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1530                             1                             3                          1530                          1531                          1650                          1651
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1531                             1                             3                          1531                          1532                          1651                          1652
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1532                             1                             3                          1532                          1533                          1652                          1653
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1533                             1                             3                          1533                          1534                          1653                          1654
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1534                             1                             3                          1534                          1535                          1654                          1655
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1535                             1                             3                          1535                          1536                          1655                          1656
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1536                             1                             3                          1536                          1537                          1656                          1657
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1537                             1                             3                          1537                          1538                          1657                          1658
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1538                             1                             3                          1538                          1539                          1658                          1659
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1539                             1                             3                          1539                          1540                          1659                          1660
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1540                             1                             3                          1540                          1541                          1660                          1661
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1541                             1                             3                          1541                          1542                          1661                          1662
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1542                             1                             3                          1542                          1543                          1662                          1663
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1543                             1                             3                          1543                          1544                          1663                          1664
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1544                             1                             3                          1544                          1545                          1664                          1665
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1545                             1                             3                          1545                          1546                          1665                          1666
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1546                             1                             3                          1546                          1547                          1666                          1667
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1547                             1                             3                          1547                          1548                          1667                          1668
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1548                             1                             3                          1548                          1549                          1668                          1669
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1549                             1                             3                          1549                          1550                          1669                          1670
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1550                             1                             3                          1550                          1551                          1670                          1671
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1551                             1                             3                          1551                          1552                          1671                          1672
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1552                             1                             3                          1552                          1553                          1672                          1673
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1553                             1                             3                          1553                          1554                          1673                          1674
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1554                             1                             3                          1554                          1555                          1674                          1675
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1555                             1                             3                          1555                          1556                          1675                          1676
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1556                             1                             3                          1556                          1557                          1676                          1677
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1557                             1                             3                          1557                          1558                          1677                          1678
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1558                             1                             3                          1558                          1559                          1678                          1679
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1559                             1                             3                          1559                          1560                          1679                          1680
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1560                             1                             3                          1560                          1441                          1680                          1561
  0.2446375819716535560122E-01  0.2087779428297099545975E-01
                          1561                             1                             3                          1561                          1562                          1681                          1682
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1562                             1                             3                          1562                          1563                          1682                          1683
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1563                             1                             3                          1563                          1564                          1683                          1684
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1564                             1                             3                          1564                          1565                          1684                          1685
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1565                             1                             3                          1565                          1566                          1685                          1686
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1566                             1                             3                          1566                          1567                          1686                          1687
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1567                             1                             3                          1567                          1568                          1687                          1688
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1568                             1                             3                          1568                          1569                          1688                          1689
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1569                             1                             3                          1569                          1570                          1689                          1690
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1570                             1                             3                          1570                          1571                          1690                          1691
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1571                             1                             3                          1571                          1572                          1691                          1692
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1572                             1                             3                          1572                          1573                          1692                          1693
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1573                             1                             3                          1573                          1574                          1693                          1694
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1574                             1                             3                          1574                          1575                          1694                          1695
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1575                             1                             3                          1575                          1576                          1695                          1696
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1576                             1                             3                          1576                          1577                          1696                          1697
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1577                             1                             3                          1577                          1578                          1697                          1698
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1578                             1                             3                          1578                          1579                          1698                          1699
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1579                             1                             3                          1579                          1580                          1699                          1700
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1580                             1                             3                          1580                          1581                          1700                          1701
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1581                             1                             3                          1581                          1582                          1701                          1702
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1582                             1                             3                          1582                          1583                          1702                          1703
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1583                             1                             3                          1583                          1584                          1703                          1704
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1584                             1                             3                          1584                          1585                          1704                          1705
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1585                             1                             3                          1585                          1586                          1705                          1706
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1586                             1                             3                          1586                          1587                          1706                          1707
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1587                             1                             3                          1587                          1588                          1707                          1708
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1588                             1                             3                          1588                          1589                          1708                          1709
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1589                             1                             3                          1589                          1590                          1709                          1710
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1590                             1                             3                          1590                          1591                          1710                          1711
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1591                             1                             3                          1591                          1592                          1711                          1712
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1592                             1                             3                          1592                          1593                          1712                          1713
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1593                             1                             3                          1593                          1594                          1713                          1714
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1594                             1                             3                          1594                          1595                          1714                          1715
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1595                             1                             3                          1595                          1596                          1715                          1716
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1596                             1                             3                          1596                          1597                          1716                          1717
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1597                             1                             3                          1597                          1598                          1717                          1718
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1598                             1                             3                          1598                          1599                          1718                          1719
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1599                             1                             3                          1599                          1600                          1719                          1720
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1600                             1                             3                          1600                          1601                          1720                          1721
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1601                             1                             3                          1601                          1602                          1721                          1722
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1602                             1                             3                          1602                          1603                          1722                          1723
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1603                             1                             3                          1603                          1604                          1723                          1724
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1604                             1                             3                          1604                          1605                          1724                          1725
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1605                             1                             3                          1605                          1606                          1725                          1726
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1606                             1                             3                          1606                          1607                          1726                          1727
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1607                             1                             3                          1607                          1608                          1727                          1728
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1608                             1                             3                          1608                          1609                          1728                          1729
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1609                             1                             3                          1609                          1610                          1729                          1730
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1610                             1                             3                          1610                          1611                          1730                          1731
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1611                             1                             3                          1611                          1612                          1731                          1732
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1612                             1                             3                          1612                          1613                          1732                          1733
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1613                             1                             3                          1613                          1614                          1733                          1734
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1614                             1                             3                          1614                          1615                          1734                          1735
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1615                             1                             3                          1615                          1616                          1735                          1736
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1616                             1                             3                          1616                          1617                          1736                          1737
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1617                             1                             3                          1617                          1618                          1737                          1738
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1618                             1                             3                          1618                          1619                          1738                          1739
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1619                             1                             3                          1619                          1620                          1739                          1740
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1620                             1                             3                          1620                          1621                          1740                          1741
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1621                             1                             3                          1621                          1622                          1741                          1742
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1622                             1                             3                          1622                          1623                          1742                          1743
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1623                             1                             3                          1623                          1624                          1743                          1744
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1624                             1                             3                          1624                          1625                          1744                          1745
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1625                             1                             3                          1625                          1626                          1745                          1746
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1626                             1                             3                          1626                          1627                          1746                          1747
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1627                             1                             3                          1627                          1628                          1747                          1748
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1628                             1                             3                          1628                          1629                          1748                          1749
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1629                             1                             3                          1629                          1630                          1749                          1750
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1630                             1                             3                          1630                          1631                          1750                          1751
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1631                             1                             3                          1631                          1632                          1751                          1752
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1632                             1                             3                          1632                          1633                          1752                          1753
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1633                             1                             3                          1633                          1634                          1753                          1754
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1634                             1                             3                          1634                          1635                          1754                          1755
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1635                             1                             3                          1635                          1636                          1755                          1756
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1636                             1                             3                          1636                          1637                          1756                          1757
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1637                             1                             3                          1637                          1638                          1757                          1758
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1638                             1                             3                          1638                          1639                          1758                          1759
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1639                             1                             3                          1639                          1640                          1759                          1760
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1640                             1                             3                          1640                          1641                          1760                          1761
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1641                             1                             3                          1641                          1642                          1761                          1762
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1642                             1                             3                          1642                          1643                          1762                          1763
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1643                             1                             3                          1643                          1644                          1763                          1764
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1644                             1                             3                          1644                          1645                          1764                          1765
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1645                             1                             3                          1645                          1646                          1765                          1766
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1646                             1                             3                          1646                          1647                          1766                          1767
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1647                             1                             3                          1647                          1648                          1767                          1768
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1648                             1                             3                          1648                          1649                          1768                          1769
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1649                             1                             3                          1649                          1650                          1769                          1770
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1650                             1                             3                          1650                          1651                          1770                          1771
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1651                             1                             3                          1651                          1652                          1771                          1772
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1652                             1                             3                          1652                          1653                          1772                          1773
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1653                             1                             3                          1653                          1654                          1773                          1774
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1654                             1                             3                          1654                          1655                          1774                          1775
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1655                             1                             3                          1655                          1656                          1775                          1776
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1656                             1                             3                          1656                          1657                          1776                          1777
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1657                             1                             3                          1657                          1658                          1777                          1778
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1658                             1                             3                          1658                          1659                          1778                          1779
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1659                             1                             3                          1659                          1660                          1779                          1780
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1660                             1                             3                          1660                          1661                          1780                          1781
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1661                             1                             3                          1661                          1662                          1781                          1782
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1662                             1                             3                          1662                          1663                          1782                          1783
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1663                             1                             3                          1663                          1664                          1783                          1784
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1664                             1                             3                          1664                          1665                          1784                          1785
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1665                             1                             3                          1665                          1666                          1785                          1786
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1666                             1                             3                          1666                          1667                          1786                          1787
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1667                             1                             3                          1667                          1668                          1787                          1788
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1668                             1                             3                          1668                          1669                          1788                          1789
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1669                             1                             3                          1669                          1670                          1789                          1790
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1670                             1                             3                          1670                          1671                          1790                          1791
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1671                             1                             3                          1671                          1672                          1791                          1792
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1672                             1                             3                          1672                          1673                          1792                          1793
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1673                             1                             3                          1673                          1674                          1793                          1794
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1674                             1                             3                          1674                          1675                          1794                          1795
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1675                             1                             3                          1675                          1676                          1795                          1796
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1676                             1                             3                          1676                          1677                          1796                          1797
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1677                             1                             3                          1677                          1678                          1797                          1798
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1678                             1                             3                          1678                          1679                          1798                          1799
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1679                             1                             3                          1679                          1680                          1799                          1800
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1680                             1                             3                          1680                          1561                          1800                          1681
  0.2445174559994318236322E-01  0.2087941320775494463691E-01
                          1681                             1                             3                          1681                          1682                          1801                          1802
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1682                             1                             3                          1682                          1683                          1802                          1803
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1683                             1                             3                          1683                          1684                          1803                          1804
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1684                             1                             3                          1684                          1685                          1804                          1805
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1685                             1                             3                          1685                          1686                          1805                          1806
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1686                             1                             3                          1686                          1687                          1806                          1807
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1687                             1                             3                          1687                          1688                          1807                          1808
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1688                             1                             3                          1688                          1689                          1808                          1809
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1689                             1                             3                          1689                          1690                          1809                          1810
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1690                             1                             3                          1690                          1691                          1810                          1811
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1691                             1                             3                          1691                          1692                          1811                          1812
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1692                             1                             3                          1692                          1693                          1812                          1813
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1693                             1                             3                          1693                          1694                          1813                          1814
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1694                             1                             3                          1694                          1695                          1814                          1815
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1695                             1                             3                          1695                          1696                          1815                          1816
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1696                             1                             3                          1696                          1697                          1816                          1817
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1697                             1                             3                          1697                          1698                          1817                          1818
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1698                             1                             3                          1698                          1699                          1818                          1819
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1699                             1                             3                          1699                          1700                          1819                          1820
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1700                             1                             3                          1700                          1701                          1820                          1821
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1701                             1                             3                          1701                          1702                          1821                          1822
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1702                             1                             3                          1702                          1703                          1822                          1823
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1703                             1                             3                          1703                          1704                          1823                          1824
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1704                             1                             3                          1704                          1705                          1824                          1825
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1705                             1                             3                          1705                          1706                          1825                          1826
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1706                             1                             3                          1706                          1707                          1826                          1827
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1707                             1                             3                          1707                          1708                          1827                          1828
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1708                             1                             3                          1708                          1709                          1828                          1829
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1709                             1                             3                          1709                          1710                          1829                          1830
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1710                             1                             3                          1710                          1711                          1830                          1831
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1711                             1                             3                          1711                          1712                          1831                          1832
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1712                             1                             3                          1712                          1713                          1832                          1833
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1713                             1                             3                          1713                          1714                          1833                          1834
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1714                             1                             3                          1714                          1715                          1834                          1835
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1715                             1                             3                          1715                          1716                          1835                          1836
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1716                             1                             3                          1716                          1717                          1836                          1837
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1717                             1                             3                          1717                          1718                          1837                          1838
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1718                             1                             3                          1718                          1719                          1838                          1839
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1719                             1                             3                          1719                          1720                          1839                          1840
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1720                             1                             3                          1720                          1721                          1840                          1841
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1721                             1                             3                          1721                          1722                          1841                          1842
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1722                             1                             3                          1722                          1723                          1842                          1843
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1723                             1                             3                          1723                          1724                          1843                          1844
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1724                             1                             3                          1724                          1725                          1844                          1845
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1725                             1                             3                          1725                          1726                          1845                          1846
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1726                             1                             3                          1726                          1727                          1846                          1847
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1727                             1                             3                          1727                          1728                          1847                          1848
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1728                             1                             3                          1728                          1729                          1848                          1849
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1729                             1                             3                          1729                          1730                          1849                          1850
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1730                             1                             3                          1730                          1731                          1850                          1851
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1731                             1                             3                          1731                          1732                          1851                          1852
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1732                             1                             3                          1732                          1733                          1852                          1853
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1733                             1                             3                          1733                          1734                          1853                          1854
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1734                             1                             3                          1734                          1735                          1854                          1855
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1735                             1                             3                          1735                          1736                          1855                          1856
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1736                             1                             3                          1736                          1737                          1856                          1857
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1737                             1                             3                          1737                          1738                          1857                          1858
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1738                             1                             3                          1738                          1739                          1858                          1859
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1739                             1                             3                          1739                          1740                          1859                          1860
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1740                             1                             3                          1740                          1741                          1860                          1861
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1741                             1                             3                          1741                          1742                          1861                          1862
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1742                             1                             3                          1742                          1743                          1862                          1863
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1743                             1                             3                          1743                          1744                          1863                          1864
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1744                             1                             3                          1744                          1745                          1864                          1865
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1745                             1                             3                          1745                          1746                          1865                          1866
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1746                             1                             3                          1746                          1747                          1866                          1867
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1747                             1                             3                          1747                          1748                          1867                          1868
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1748                             1                             3                          1748                          1749                          1868                          1869
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1749                             1                             3                          1749                          1750                          1869                          1870
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1750                             1                             3                          1750                          1751                          1870                          1871
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1751                             1                             3                          1751                          1752                          1871                          1872
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1752                             1                             3                          1752                          1753                          1872                          1873
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1753                             1                             3                          1753                          1754                          1873                          1874
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1754                             1                             3                          1754                          1755                          1874                          1875
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1755                             1                             3                          1755                          1756                          1875                          1876
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1756                             1                             3                          1756                          1757                          1876                          1877
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1757                             1                             3                          1757                          1758                          1877                          1878
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1758                             1                             3                          1758                          1759                          1878                          1879
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1759                             1                             3                          1759                          1760                          1879                          1880
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1760                             1                             3                          1760                          1761                          1880                          1881
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1761                             1                             3                          1761                          1762                          1881                          1882
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1762                             1                             3                          1762                          1763                          1882                          1883
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1763                             1                             3                          1763                          1764                          1883                          1884
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1764                             1                             3                          1764                          1765                          1884                          1885
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1765                             1                             3                          1765                          1766                          1885                          1886
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1766                             1                             3                          1766                          1767                          1886                          1887
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1767                             1                             3                          1767                          1768                          1887                          1888
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1768                             1                             3                          1768                          1769                          1888                          1889
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1769                             1                             3                          1769                          1770                          1889                          1890
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1770                             1                             3                          1770                          1771                          1890                          1891
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1771                             1                             3                          1771                          1772                          1891                          1892
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1772                             1                             3                          1772                          1773                          1892                          1893
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1773                             1                             3                          1773                          1774                          1893                          1894
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1774                             1                             3                          1774                          1775                          1894                          1895
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1775                             1                             3                          1775                          1776                          1895                          1896
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1776                             1                             3                          1776                          1777                          1896                          1897
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1777                             1                             3                          1777                          1778                          1897                          1898
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1778                             1                             3                          1778                          1779                          1898                          1899
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1779                             1                             3                          1779                          1780                          1899                          1900
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1780                             1                             3                          1780                          1781                          1900                          1901
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1781                             1                             3                          1781                          1782                          1901                          1902
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1782                             1                             3                          1782                          1783                          1902                          1903
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1783                             1                             3                          1783                          1784                          1903                          1904
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1784                             1                             3                          1784                          1785                          1904                          1905
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1785                             1                             3                          1785                          1786                          1905                          1906
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1786                             1                             3                          1786                          1787                          1906                          1907
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1787                             1                             3                          1787                          1788                          1907                          1908
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1788                             1                             3                          1788                          1789                          1908                          1909
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1789                             1                             3                          1789                          1790                          1909                          1910
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1790                             1                             3                          1790                          1791                          1910                          1911
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1791                             1                             3                          1791                          1792                          1911                          1912
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1792                             1                             3                          1792                          1793                          1912                          1913
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1793                             1                             3                          1793                          1794                          1913                          1914
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1794                             1                             3                          1794                          1795                          1914                          1915
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1795                             1                             3                          1795                          1796                          1915                          1916
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1796                             1                             3                          1796                          1797                          1916                          1917
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1797                             1                             3                          1797                          1798                          1917                          1918
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1798                             1                             3                          1798                          1799                          1918                          1919
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1799                             1                             3                          1799                          1800                          1919                          1920
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1800                             1                             3                          1800                          1681                          1920                          1801
  0.2443786450795362719113E-01  0.2087844553861300384012E-01
                          1801                             1                             3                          1801                          1802                          1921                          1922
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1802                             1                             3                          1802                          1803                          1922                          1923
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1803                             1                             3                          1803                          1804                          1923                          1924
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1804                             1                             3                          1804                          1805                          1924                          1925
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1805                             1                             3                          1805                          1806                          1925                          1926
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1806                             1                             3                          1806                          1807                          1926                          1927
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1807                             1                             3                          1807                          1808                          1927                          1928
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1808                             1                             3                          1808                          1809                          1928                          1929
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1809                             1                             3                          1809                          1810                          1929                          1930
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1810                             1                             3                          1810                          1811                          1930                          1931
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1811                             1                             3                          1811                          1812                          1931                          1932
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1812                             1                             3                          1812                          1813                          1932                          1933
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1813                             1                             3                          1813                          1814                          1933                          1934
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1814                             1                             3                          1814                          1815                          1934                          1935
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1815                             1                             3                          1815                          1816                          1935                          1936
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1816                             1                             3                          1816                          1817                          1936                          1937
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1817                             1                             3                          1817                          1818                          1937                          1938
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1818                             1                             3                          1818                          1819                          1938                          1939
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1819                             1                             3                          1819                          1820                          1939                          1940
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1820                             1                             3                          1820                          1821                          1940                          1941
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1821                             1                             3                          1821                          1822                          1941                          1942
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1822                             1                             3                          1822                          1823                          1942                          1943
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1823                             1                             3                          1823                          1824                          1943                          1944
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1824                             1                             3                          1824                          1825                          1944                          1945
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1825                             1                             3                          1825                          1826                          1945                          1946
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1826                             1                             3                          1826                          1827                          1946                          1947
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1827                             1                             3                          1827                          1828                          1947                          1948
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1828                             1                             3                          1828                          1829                          1948                          1949
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1829                             1                             3                          1829                          1830                          1949                          1950
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1830                             1                             3                          1830                          1831                          1950                          1951
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1831                             1                             3                          1831                          1832                          1951                          1952
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1832                             1                             3                          1832                          1833                          1952                          1953
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1833                             1                             3                          1833                          1834                          1953                          1954
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1834                             1                             3                          1834                          1835                          1954                          1955
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1835                             1                             3                          1835                          1836                          1955                          1956
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
