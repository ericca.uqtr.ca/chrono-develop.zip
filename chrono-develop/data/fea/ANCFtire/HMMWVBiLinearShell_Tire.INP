  0.4830614558194835234106E-01 -0.1043862266863211651913E+00  0.9269022744453918605245E+00 -0.9685352871511762606893E-01  0.3761084501259887580282E+00 -0.9214997708731437198182E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           900                             0                             0                             0                             0                             0                             0
  0.2418621916375637490026E-01 -0.1043862266863211651913E+00  0.9288005538229876512091E+00 -0.4849322263381720260478E-01  0.3761084501259887025171E+00 -0.9253058095043029673832E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           901                             0                             0                             0                             0                             0                             0
  0.2335262146559013988518E-15 -0.1043862266863211651913E+00  0.9294338922610649866840E+00 -0.4682186430821379245352E-15  0.3761084501259887025171E+00 -0.9265756492288292900383E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           902                             0                             0                             0                             0                             0                             0
 -0.2418621916375631938911E-01 -0.1043862266863211651913E+00  0.9288005538229876512091E+00  0.4849322263381708464358E-01  0.3761084501259887025171E+00 -0.9253058095043029673832E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           903                             0                             0                             0                             0                             0                             0
 -0.4830614558194828989102E-01 -0.1043862266863211651913E+00  0.9269022744453918605245E+00  0.9685352871511751504663E-01  0.3761084501259887580282E+00 -0.9214997708731437198182E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           904                             0                             0                             0                             0                             0                             0
 -0.7229366821281936472676E-01 -0.1043862266863211651913E+00  0.9237442571801034452150E+00  0.1449483660064164736170E+00  0.3761084501259887025171E+00 -0.9151679654226848592558E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           905                             0                             0                             0                             0                             0                             0
 -0.9608303892419015057591E-01 -0.1043862266863211651913E+00  0.9193351579329357425863E+00  0.1926459099017287790456E+00  0.3761084501259887025171E+00 -0.9063277481915477107322E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           906                             0                             0                             0                             0                             0                             0
 -0.1196090527045198803613E+00 -0.1043862266863211651913E+00  0.9136870617384524884130E+00  0.2398154247486534995648E+00  0.3761084501259887580282E+00 -0.8950033496006869482287E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           907                             0                             0                             0                             0                             0                             0
 -0.1428072263853100432041E+00 -0.1043862266863211651913E+00  0.9068154496357283544938E+00  0.2863276221857083414513E+00  0.3761084501259887580282E+00 -0.8812258090394906595577E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           908                             0                             0                             0                             0                             0                             0
 -0.1656139753849864559854E+00 -0.1043862266863211651913E+00  0.8987391562358970631408E+00  0.3320550155127407476741E+00  0.3761084501259887025171E+00 -0.8650328897889721924130E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           909                             0                             0                             0                             0                             0                             0
 -0.1879667879898191396038E+00 -0.1043862266863211651913E+00  0.8894803180977910450622E+00  0.3768722691231142229995E+00  0.3761084501259887025171E+00 -0.8464689755152409178507E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           910                             0                             0                             0                             0                             0                             0
 -0.2098043966941827154216E+00 -0.1043862266863211651913E+00  0.8790643130531732296618E+00  0.4206565420398911125943E+00  0.3761084501259887025171E+00 -0.8255849486169595241591E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           911                             0                             0                             0                             0                             0                             0
 -0.2310669461305323857392E+00 -0.1043862266863211651913E+00  0.8675196906478630509696E+00  0.4632878246144144229746E+00  0.3761084501259886470059E+00 -0.8024380507602253409516E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           912                             0                             0                             0                             0                             0                             0
 -0.2516961571288049426265E+00 -0.1043862266863211651913E+00  0.8548780938894167125142E+00  0.5046492674644118547889E+00  0.3761084501259886470059E+00 -0.7770917259831421342042E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           913                             0                             0                             0                             0                             0                             0
 -0.2716354864555726167374E+00 -0.1043862266863211651913E+00  0.8411741725158425886377E+00  0.5446275017500293857964E+00  0.3761084501259886470059E+00 -0.7496154468001230419816E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           914                             0                             0                             0                             0                             0                             0
 -0.2908302817951167740240E+00 -0.1043862266863211651913E+00  0.8264454880230776012695E+00  0.5831129499099436674925E+00  0.3761084501259887025171E+00 -0.7200845237825556077738E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           915                             0                             0                             0                             0                             0                             0
 -0.3092279315476256784656E+00 -0.1043862266863211651913E+00  0.8107324107115381206512E+00  0.6200001260058393137697E+00  0.3761084501259887025171E+00 -0.6885798991377616307119E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           916                             0                             0                             0                             0                             0                             0
 -0.3267780090339323928461E+00 -0.1043862266863211651913E+00  0.7940780090339324415183E+00  0.6551879248520329213079E+00  0.3761084501259887025171E+00 -0.6551879248520330323302E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           917                             0                             0                             0                             0                             0                             0
 -0.3434324107115379609567E+00 -0.1043862266863211651913E+00  0.7765279315476256716266E+00  0.6885798991377614086673E+00  0.3761084501259885914948E+00 -0.6200001260058394247920E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           918                             0                             0                             0                             0                             0                             0
 -0.3591454880230774415750E+00 -0.1043862266863211651913E+00  0.7581302817951169892297E+00  0.7200845237825553857292E+00  0.3761084501259887025171E+00 -0.5831129499099441115817E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           919                             0                             0                             0                             0                             0                             0
 -0.3738741725158425399655E+00 -0.1043862266863211651913E+00  0.7389354864555727209208E+00  0.7496154468001229309593E+00  0.3761084501259887025171E+00 -0.5446275017500296078410E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           920                             0                             0                             0                             0                             0                             0
 -0.3875780938894168303754E+00 -0.1043862266863211651913E+00  0.7189961571288048247652E+00  0.7770917259831423562488E+00  0.3761084501259887025171E+00 -0.5046492674644117437666E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           921                             0                             0                             0                             0                             0                             0
 -0.4002196906478630022974E+00 -0.1043862266863211651913E+00  0.6983669461305326287004E+00  0.8024380507602251189070E+00  0.3761084501259887025171E+00 -0.4632878246144149780861E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           922                             0                             0                             0                             0                             0                             0
 -0.4117643130531731809896E+00 -0.1043862266863211651913E+00  0.6771043966941827640937E+00  0.8255849486169595241591E+00  0.3761084501259886470059E+00 -0.4206565420398912791278E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           923                             0                             0                             0                             0                             0                             0
 -0.4221803180977909408789E+00 -0.1043862266863211651913E+00  0.6552667879898194103205E+00  0.8464689755152406958061E+00  0.3761084501259887580282E+00 -0.3768722691231147781110E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           924                             0                             0                             0                             0                             0                             0
 -0.4314391562358970144686E+00 -0.1043862266863211651913E+00  0.6329139753849863936352E+00  0.8650328897889723034353E+00  0.3761084501259887025171E+00 -0.3320550155127405256295E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           925                             0                             0                             0                             0                             0                             0
 -0.4395154496357283058217E+00 -0.1043862266863211651913E+00  0.6101072263853101196318E+00  0.8812258090394905485354E+00  0.3761084501259887025171E+00 -0.2863276221857084524736E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           926                             0                             0                             0                             0                             0                             0
 -0.4463870617384524952520E+00 -0.1043862266863211651913E+00  0.5869090527045199845446E+00  0.8950033496006868372064E+00  0.3761084501259887025171E+00 -0.2398154247486536383427E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           927                             0                             0                             0                             0                             0                             0
 -0.4520351579329357494252E+00 -0.1043862266863211651913E+00  0.5633830389241903935371E+00  0.9063277481915475997098E+00  0.3761084501259887025171E+00 -0.1926459099017293619127E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           928                             0                             0                             0                             0                             0                             0
 -0.4564442571801033965428E+00 -0.1043862266863211651913E+00  0.5395936682128193995212E+00  0.9151679654226847482335E+00  0.3761084501259887025171E+00 -0.1449483660064166123949E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           929                             0                             0                             0                             0                             0                             0
 -0.4596022744453917563412E+00 -0.1043862266863211651913E+00  0.5156061455819487271413E+00  0.9214997708731436087959E+00  0.3761084501259887025171E+00 -0.9685352871511850036956E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           930                             0                             0                             0                             0                             0                             0
 -0.4615005538229877135592E+00 -0.1043862266863211651913E+00  0.4914862191637561772417E+00  0.9253058095043030784055E+00  0.3761084501259887025171E+00 -0.4849322263381684872119E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           931                             0                             0                             0                             0                             0                             0
 -0.4621338922610649935230E+00 -0.1043862266863211651913E+00  0.4673000000000000486722E+00  0.9265756492288292900383E+00  0.3761084501259887025171E+00 -0.1134727902995966400235E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           932                             0                             0                             0                             0                             0                             0
 -0.4615005538229876580480E+00 -0.1043862266863211651913E+00  0.4431137808362434760134E+00  0.9253058095043029673832E+00  0.3761084501259887025171E+00  0.4849322263381743852717E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           933                             0                             0                             0                             0                             0                             0
 -0.4596022744453918118523E+00 -0.1043862266863211651913E+00  0.4189938544180517032700E+00  0.9214997708731437198182E+00  0.3761084501259887580282E+00  0.9685352871511745953548E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           934                             0                             0                             0                             0                             0                             0
 -0.4564442571801034520540E+00 -0.1043862266863211651913E+00  0.3950063317871806978232E+00  0.9151679654226848592558E+00  0.3761084501259887025171E+00  0.1449483660064163903503E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           935                             0                             0                             0                             0                             0                             0
 -0.4520351579329357494252E+00 -0.1043862266863211651913E+00  0.3712169610758096482961E+00  0.9063277481915475997098E+00  0.3761084501259886470059E+00  0.1926459099017291398681E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           936                             0                             0                             0                             0                             0                             0
 -0.4463870617384524397409E+00 -0.1043862266863211651913E+00  0.3476909472954797797328E+00  0.8950033496006867261841E+00  0.3761084501259887025171E+00  0.2398154247486542212098E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           937                             0                             0                             0                             0                             0                             0
 -0.4395154496357283613328E+00 -0.1043862266863211651913E+00  0.3244927736146899777125E+00  0.8812258090394906595577E+00  0.3761084501259887580282E+00  0.2863276221857082859401E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           938                             0                             0                             0                             0                             0                             0
 -0.4314391562358970144686E+00 -0.1043862266863211651913E+00  0.3016860246150137037091E+00  0.8650328897889723034353E+00  0.3761084501259886470059E+00  0.3320550155127403035848E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           939                             0                             0                             0                             0                             0                             0
 -0.4221803180977911074123E+00 -0.1043862266863211651913E+00  0.2793332120101810756019E+00  0.8464689755152410288730E+00  0.3761084501259887025171E+00  0.3768722691231138344214E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           940                             0                             0                             0                             0                             0                             0
 -0.4117643130531732365007E+00 -0.1043862266863211651913E+00  0.2574956033058172777395E+00  0.8255849486169595241591E+00  0.3761084501259887025171E+00  0.4206565420398911125943E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           941                             0                             0                             0                             0                             0                             0
 -0.4002196906478630578086E+00 -0.1043862266863211651913E+00  0.2362330538694674408884E+00  0.8024380507602252299293E+00  0.3761084501259887025171E+00  0.4632878246144147560415E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           942                             0                             0                             0                             0                             0                             0
 -0.3875780938894168858866E+00 -0.1043862266863211651913E+00  0.2156038428711952170680E+00  0.7770917259831424672711E+00  0.3761084501259887025171E+00  0.5046492674644115217220E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           943                             0                             0                             0                             0                             0                             0
 -0.3738741725158426509878E+00 -0.1043862266863211651913E+00  0.1956645135444273764236E+00  0.7496154468001231530039E+00  0.3761084501259887025171E+00  0.5446275017500293857964E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           944                             0                             0                             0                             0                             0                             0
 -0.3591454880230777746419E+00 -0.1043862266863211651913E+00  0.1764697182048833856705E+00  0.7200845237825559408407E+00  0.3761084501259887025171E+00  0.5831129499099433344256E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           945                             0                             0                             0                             0                             0                             0
 -0.3434324107115379054456E+00 -0.1043862266863211651913E+00  0.1580720684523741481620E+00  0.6885798991377612976450E+00  0.3761084501259887025171E+00  0.6200001260058395358143E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           946                             0                             0                             0                             0                             0                             0
 -0.3267780090339325038684E+00 -0.1043862266863211651913E+00  0.1405219909660676003149E+00  0.6551879248520331433525E+00  0.3761084501259887025171E+00  0.6551879248520329213079E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           947                             0                             0                             0                             0                             0                             0
 -0.3092279315476256229545E+00 -0.1043862266863211651913E+00  0.1238675892884618656709E+00  0.6200001260058392027474E+00  0.3761084501259887025171E+00  0.6885798991377617417342E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           948                             0                             0                             0                             0                             0                             0
 -0.2908302817951170515798E+00 -0.1043862266863211651913E+00  0.1081545119769226070972E+00  0.5831129499099442226040E+00  0.3761084501259887025171E+00  0.7200845237825552747069E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           949                             0                             0                             0                             0                             0                             0
 -0.2716354864555727277597E+00 -0.1043862266863211651913E+00  0.9342582748415745319548E-01  0.5446275017500296078410E+00  0.3761084501259887025171E+00  0.7496154468001229309593E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           950                             0                             0                             0                             0                             0                             0
 -0.2516961571288052201822E+00 -0.1043862266863211651913E+00  0.7972190611058338483019E-01  0.5046492674644124099004E+00  0.3761084501259887025171E+00  0.7770917259831419121596E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           951                             0                             0                             0                             0                             0                             0
 -0.2310669461305323302280E+00 -0.1043862266863211651913E+00  0.6708030935213682433016E-01  0.4632878246144143119523E+00  0.3761084501259887025171E+00  0.8024380507602254519739E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           952                             0                             0                             0                             0                             0                             0
 -0.2098043966941828264439E+00 -0.1043862266863211651913E+00  0.5553568694682681217145E-01  0.4206565420398913346389E+00  0.3761084501259887025171E+00  0.8255849486169595241591E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           953                             0                             0                             0                             0                             0                             0
 -0.1879667879898190563370E+00 -0.1043862266863211651913E+00  0.4511968190220894125986E-01  0.3768722691231141119772E+00  0.3761084501259887580282E+00  0.8464689755152409178507E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           954                             0                             0                             0                             0                             0                             0
 -0.1656139753849867612967E+00 -0.1043862266863211651913E+00  0.3586084376410308971472E-01  0.3320550155127413582967E+00  0.3761084501259887580282E+00  0.8650328897889719703684E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           955                             0                             0                             0                             0                             0                             0
 -0.1428072263853101542264E+00 -0.1043862266863211651913E+00  0.2778455036427168733937E-01  0.2863276221857085079847E+00  0.3761084501259887025171E+00  0.8812258090394905485354E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           956                             0                             0                             0                             0                             0                             0
 -0.1196090527045199913836E+00 -0.1043862266863211651913E+00  0.2091293826154749790902E-01  0.2398154247486536938538E+00  0.3761084501259887025171E+00  0.8950033496006868372064E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           957                             0                             0                             0                             0                             0                             0
 -0.9608303892419005343140E-01 -0.1043862266863211651913E+00  0.1526484206706424373579E-01  0.1926459099017286125122E+00  0.3761084501259887025171E+00  0.9063277481915477107322E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           958                             0                             0                             0                             0                             0                             0
 -0.7229366821281946187128E-01 -0.1043862266863211651913E+00  0.1085574281989659661818E-01  0.1449483660064166679060E+00  0.3761084501259887025171E+00  0.9151679654226847482335E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           959                             0                             0                             0                             0                             0                             0
 -0.4830614558194840785221E-01 -0.1043862266863211651913E+00  0.7697725554608181308680E-02  0.9685352871511775096902E-01  0.3761084501259887580282E+00  0.9214997708731437198182E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           960                             0                             0                             0                             0                             0                             0
 -0.2418621916375663510879E-01 -0.1043862266863211651913E+00  0.5799446177012335112977E-02  0.4849322263381772302182E-01  0.3761084501259887025171E+00  0.9253058095043029673832E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           961                             0                             0                             0                             0                             0                             0
  0.2855786811015745030862E-16 -0.8350873084007630342551E-01  0.9146204760335785444170E-03 -0.6113906976003832489457E-16  0.5517350488583738776782E-01  0.9984767820828949203005E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           962                             0                             0                             0                             0                             0                             0
  0.2440872481511512093189E-01 -0.8350873084007630342551E-01  0.1553785429646070692655E-02 -0.5225623717668588519292E-01  0.5517350488583738082893E-01  0.9971084043546853958873E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           963                             0                             0                             0                             0                             0                             0
  0.4875054701214154295741E-01 -0.8350873084007630342551E-01  0.3469528383773456958750E-02 -0.1043692436395567135765E+00  0.5517350488583738776782E-01  0.9930070217982950309121E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           964                             0                             0                             0                             0                             0                             0
  0.7295874734841675812724E-01 -0.8350873084007630342551E-01  0.6656598420140047434046E-02 -0.1561961812602288834917E+00  0.5517350488583739470672E-01  0.9861838760182274343791E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           965                             0                             0                             0                             0                             0                             0
  0.9696697282951030616438E-01 -0.8350873084007630342551E-01  0.1110626000130693347145E-01 -0.2075949960051302334296E+00  0.5517350488583738082893E-01  0.9766576687827944747156E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           966                             0                             0                             0                             0                             0                             0
  0.1207094185781697193161E+00 -0.8350873084007630342551E-01  0.1680631691417200368477E-01 -0.2584248072957325281784E+00  0.5517350488583738776782E-01  0.9644545107638702319264E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           967                             0                             0                             0                             0                             0                             0
  0.1441210082009152515514E+00 -0.8350873084007630342551E-01  0.2374114569894347770429E-01 -0.3085462941524255708892E+00  0.5517350488583738082893E-01  0.9496078499693532126713E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           968                             0                             0                             0                             0                             0                             0
  0.1671375721579105577685E+00 -0.8350873084007630342551E-01  0.3189173847195614364125E-01 -0.3578220770636367786821E+00  0.5517350488583738776782E-01  0.9321583800645025785769E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           969                             0                             0                             0                             0                             0                             0
  0.1896960236472111371864E+00 -0.8350873084007630342551E-01  0.4123575502496001909947E-01 -0.4061170945335239590435E+00  0.5517350488583738776782E-01  0.9121539288334297168603E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           970                             0                             0                             0                             0                             0                             0
  0.2117345315213036982538E+00 -0.8350873084007630342551E-01  0.5174758405807794447995E-01 -0.4532989732761480428103E+00  0.5517350488583738082893E-01  0.8896493270864664903996E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           971                             0                             0                             0                             0                             0                             0
  0.2331926897619831517972E+00 -0.8350873084007630342551E-01  0.6339841337859830616708E-01 -0.4992383910414473491279E+00  0.5517350488583738776782E-01  0.8647062583727260776101E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           972                             0                             0                             0                             0                             0                             0
  0.2540116830490502519702E+00 -0.8350873084007630342551E-01  0.7615630887319291275617E-01 -0.5438094310785374085881E+00  0.5517350488583738776782E-01  0.8373930899097808966403E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           973                             0                             0                             0                             0                             0                             0
  0.2741344479690154267715E+00 -0.8350873084007630342551E-01  0.8998630203710150654572E-01 -0.5868899272647710718687E+00  0.5517350488583739470672E-01  0.8077846851938730310394E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           974                             0                             0                             0                             0                             0                             0
  0.2935058294219494157140E+00 -0.8350873084007630342551E-01  0.1048504858203728740129E+00 -0.6283617989545907667193E+00  0.5517350488583738776782E-01  0.7759621988042736395741E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           975                             0                             0                             0                             0                             0                             0
  0.3120727317977778914049E+00 -0.8350873084007630342551E-01  0.1207081185284537561131E+00 -0.6681113746303690703598E+00  0.5517350488583738082893E-01  0.7420128539642230069973E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           976                             0                             0                             0                             0                             0                             0
  0.3297842645076581868935E+00 -0.8350873084007630342551E-01  0.1375157354923417507564E+00 -0.7060297034681376482368E+00  0.5517350488583738776782E-01  0.7060297034681377592591E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           977                             0                             0                             0                             0                             0                             0
  0.3465918814715462925591E+00 -0.8350873084007630342551E-01  0.1552272682022221017561E+00 -0.7420128539642231180196E+00  0.5517350488583738776782E-01  0.6681113746303690703598E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           978                             0                             0                             0                             0                             0                             0
  0.3624495141796271746593E+00 -0.8350873084007630342551E-01  0.1737941705780506329582E+00 -0.7759621988042737505964E+00  0.5517350488583738082893E-01  0.6283617989545906556970E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           979                             0                             0                             0                             0                             0                             0
  0.3773136979628984866153E+00 -0.8350873084007630342551E-01  0.1931655520309845663895E+00 -0.8077846851938730310394E+00  0.5517350488583739470672E-01  0.5868899272647710718687E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           980                             0                             0                             0                             0                             0                             0
  0.3911436911268070804049E+00 -0.8350873084007630342551E-01  0.2132883169509497411909E+00 -0.8373930899097808966403E+00  0.5517350488583738776782E-01  0.5438094310785374085881E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           981                             0                             0                             0                             0                             0                             0
  0.4039015866214016314828E+00 -0.8350873084007630342551E-01  0.2341073102380167858527E+00 -0.8647062583727259665878E+00  0.5517350488583738776782E-01  0.4992383910414474601502E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           982                             0                             0                             0                             0                             0                             0
  0.4155524159419221041922E+00 -0.8350873084007630342551E-01  0.2555654684786963226628E+00 -0.8896493270864666014219E+00  0.5517350488583738776782E-01  0.4532989732761479872991E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           983                             0                             0                             0                             0                             0                             0
  0.4260642449750399740616E+00 -0.8350873084007630342551E-01  0.2776039763527887727079E+00 -0.9121539288334297168603E+00  0.5517350488583739470672E-01  0.4061170945335240700658E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           984                             0                             0                             0                             0                             0                             0
  0.4354082615280438495198E+00 -0.8350873084007630342551E-01  0.3001624278420894631481E+00 -0.9321583800645025785769E+00  0.5517350488583738776782E-01  0.3578220770636367231710E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           985                             0                             0                             0                             0                             0                             0
  0.4435588543010565154567E+00 -0.8350873084007630342551E-01  0.3231789917990847693652E+00 -0.9496078499693532126713E+00  0.5517350488583738082893E-01  0.3085462941524255153780E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           986                             0                             0                             0                             0                             0                             0
  0.4504936830858279894763E+00 -0.8350873084007630342551E-01  0.3465905814218303016006E+00 -0.9644545107638702319264E+00  0.5517350488583738776782E-01  0.2584248072957324726673E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           987                             0                             0                             0                             0                             0                             0
  0.4561937399986931152007E+00 -0.8350873084007630342551E-01  0.3703330271704898257745E+00 -0.9766576687827945857379E+00  0.5517350488583738776782E-01  0.2075949960051299558739E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           988                             0                             0                             0                             0                             0                             0
  0.4606434015798599457270E+00 -0.8350873084007630342551E-01  0.3943412526515832627894E+00 -0.9861838760182274343791E+00  0.5517350488583739470672E-01  0.1561961812602288279805E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           989                             0                             0                             0                             0                             0                             0
  0.4638304716162265362023E+00 -0.8350873084007630342551E-01  0.4185494529878585057148E+00 -0.9930070217982950309121E+00  0.5517350488583738776782E-01  0.1043692436395566441876E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           990                             0                             0                             0                             0                             0                             0
  0.4657462145703539224684E+00 -0.8350873084007630342551E-01  0.4428912751848850248848E+00 -0.9971084043546853958873E+00  0.5517350488583738082893E-01  0.5225623717668560069827E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           991                             0                             0                             0                             0                             0                             0
  0.4663853795239664146166E+00 -0.8350873084007630342551E-01  0.4672999999999998821387E+00 -0.9984767820828949203005E+00  0.5517350488583738776782E-01  0.2217063826044129815741E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           992                             0                             0                             0                             0                             0                             0
  0.4657462145703539224684E+00 -0.8350873084007630342551E-01  0.4917087248151149614372E+00 -0.9971084043546853958873E+00  0.5517350488583738082893E-01 -0.5225623717668560069827E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           993                             0                             0                             0                             0                             0                             0
  0.4638304716162265362023E+00 -0.8350873084007630342551E-01  0.5160505470121414806073E+00 -0.9930070217982950309121E+00  0.5517350488583738776782E-01 -0.1043692436395566441876E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           994                             0                             0                             0                             0                             0                             0
  0.4606434015798599457270E+00 -0.8350873084007630342551E-01  0.5402587473484167235327E+00 -0.9861838760182274343791E+00  0.5517350488583739470672E-01 -0.1561961812602288279805E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           995                             0                             0                             0                             0                             0                             0
  0.4561937399986930596896E+00 -0.8350873084007630342551E-01  0.5642669728295102160587E+00 -0.9766576687827944747156E+00  0.5517350488583738082893E-01 -0.2075949960051301779185E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           996                             0                             0                             0                             0                             0                             0
  0.4504936830858279894763E+00 -0.8350873084007630342551E-01  0.5880094185781696847215E+00 -0.9644545107638702319264E+00  0.5517350488583738776782E-01 -0.2584248072957324726673E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           997                             0                             0                             0                             0                             0                             0
  0.4435588543010565154567E+00 -0.8350873084007630342551E-01  0.6114210082009152724680E+00 -0.9496078499693532126713E+00  0.5517350488583738082893E-01 -0.3085462941524255153780E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           998                             0                             0                             0                             0                             0                             0
  0.4354082615280438495198E+00 -0.8350873084007630342551E-01  0.6344375721579105231740E+00 -0.9321583800645025785769E+00  0.5517350488583738776782E-01 -0.3578220770636367231710E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           999                             0                             0                             0                             0                             0                             0
  0.4260642449750400295727E+00 -0.8350873084007630342551E-01  0.6569960236472111025918E+00 -0.9121539288334298278826E+00  0.5517350488583738776782E-01 -0.4061170945335239035323E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1000                             0                             0                             0                             0                             0                             0
  0.4155524159419221041922E+00 -0.8350873084007630342551E-01  0.6790345315213036636592E+00 -0.8896493270864666014219E+00  0.5517350488583738776782E-01 -0.4532989732761479872991E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1001                             0                             0                             0                             0                             0                             0
  0.4039015866214016869939E+00 -0.8350873084007630342551E-01  0.7004926897619830894470E+00 -0.8647062583727260776101E+00  0.5517350488583738776782E-01 -0.4992383910414472936168E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1002                             0                             0                             0                             0                             0                             0
  0.3911436911268071359160E+00 -0.8350873084007630342551E-01  0.7213116830490501341089E+00 -0.8373930899097810076626E+00  0.5517350488583738082893E-01 -0.5438094310785371865435E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1003                             0                             0                             0                             0                             0                             0
  0.3773136979628984866153E+00 -0.8350873084007630342551E-01  0.7414344479690153644214E+00 -0.8077846851938730310394E+00  0.5517350488583739470672E-01 -0.5868899272647710718687E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1004                             0                             0                             0                             0                             0                             0
  0.3624495141796271746593E+00 -0.8350873084007630342551E-01  0.7608058294219492978527E+00 -0.7759621988042738616187E+00  0.5517350488583738776782E-01 -0.6283617989545905446747E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1005                             0                             0                             0                             0                             0                             0
  0.3465918814715464035814E+00 -0.8350873084007630342551E-01  0.7793727317977777735436E+00 -0.7420128539642233400642E+00  0.5517350488583738776782E-01 -0.6681113746303688483152E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1006                             0                             0                             0                             0                             0                             0
  0.3297842645076582424046E+00 -0.8350873084007630342551E-01  0.7970842645076581245434E+00 -0.7060297034681377592591E+00  0.5517350488583738776782E-01 -0.7060297034681376482368E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1007                             0                             0                             0                             0                             0                             0
  0.3120727317977779469160E+00 -0.8350873084007630342551E-01  0.8138918814715462302090E+00 -0.6681113746303691813822E+00  0.5517350488583738776782E-01 -0.7420128539642230069973E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1008                             0                             0                             0                             0                             0                             0
  0.2935058294219493602029E+00 -0.8350873084007630342551E-01  0.8297495141796271678203E+00 -0.6283617989545906556970E+00  0.5517350488583738082893E-01 -0.7759621988042737505964E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1009                             0                             0                             0                             0                             0                             0
  0.2741344479690154267715E+00 -0.8350873084007630342551E-01  0.8446136979628984242652E+00 -0.5868899272647710718687E+00  0.5517350488583739470672E-01 -0.8077846851938730310394E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1010                             0                             0                             0                             0                             0                             0
  0.2540116830490503074813E+00 -0.8350873084007630342551E-01  0.8584436911268069625436E+00 -0.5438094310785375196104E+00  0.5517350488583738776782E-01 -0.8373930899097807856180E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1011                             0                             0                             0                             0                             0                             0
  0.2331926897619831517972E+00 -0.8350873084007630342551E-01  0.8712015866214016801550E+00 -0.4992383910414473491279E+00  0.5517350488583738776782E-01 -0.8647062583727260776101E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1012                             0                             0                             0                             0                             0                             0
  0.2117345315213036982538E+00 -0.8350873084007630342551E-01  0.8828524159419219863310E+00 -0.4532989732761480428103E+00  0.5517350488583738082893E-01 -0.8896493270864664903996E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1013                             0                             0                             0                             0                             0                             0
  0.1896960236472110539196E+00 -0.8350873084007630342551E-01  0.8933642449750400782449E+00 -0.4061170945335237369989E+00  0.5517350488583738776782E-01 -0.9121539288334298278826E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1014                             0                             0                             0                             0                             0                             0
  0.1671375721579104745018E+00 -0.8350873084007630342551E-01  0.9027082615280438426808E+00 -0.3578220770636365566375E+00  0.5517350488583738082893E-01 -0.9321583800645025785769E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1015                             0                             0                             0                             0                             0                             0
  0.1441210082009152515514E+00 -0.8350873084007630342551E-01  0.9108588543010565086178E+00 -0.3085462941524255708892E+00  0.5517350488583738082893E-01 -0.9496078499693532126713E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1016                             0                             0                             0                             0                             0                             0
  0.1207094185781696082937E+00 -0.8350873084007630342551E-01  0.9177936830858279826373E+00 -0.2584248072957323061338E+00  0.5517350488583738082893E-01 -0.9644545107638702319264E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1017                             0                             0                             0                             0                             0                             0
  0.9696697282951020901987E-01 -0.8350873084007630342551E-01  0.9234937399986931083617E+00 -0.2075949960051300113850E+00  0.5517350488583739470672E-01 -0.9766576687827945857379E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1018                             0                             0                             0                             0                             0                             0
  0.7295874734841675812724E-01 -0.8350873084007630342551E-01  0.9279434015798599943992E+00 -0.1561961812602288834917E+00  0.5517350488583739470672E-01 -0.9861838760182274343791E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1019                             0                             0                             0                             0                             0                             0
  0.4875054701214143887400E-01 -0.8350873084007630342551E-01  0.9311304716162265293633E+00 -0.1043692436395564915319E+00  0.5517350488583739470672E-01 -0.9930070217982951419344E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1020                             0                             0                             0                             0                             0                             0
  0.2440872481511501684848E-01 -0.8350873084007630342551E-01  0.9330462145703539711405E+00 -0.5225623717668566314831E-01  0.5517350488583738082893E-01 -0.9971084043546853958873E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1021                             0                             0                             0                             0                             0                             0
  0.2356745827885772554537E-15 -0.8350873084007630342551E-01  0.9336853795239663522665E+00 -0.5045518349688643003687E-15  0.5517350488583738776782E-01 -0.9984767820828949203005E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1022                             0                             0                             0                             0                             0                             0
 -0.2440872481511495786788E-01 -0.8350873084007630342551E-01  0.9330462145703539711405E+00  0.5225623717668553824822E-01  0.5517350488583738082893E-01 -0.9971084043546853958873E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1023                             0                             0                             0                             0                             0                             0
 -0.4875054701214137642395E-01 -0.8350873084007630342551E-01  0.9311304716162265293633E+00  0.1043692436395563666318E+00  0.5517350488583739470672E-01 -0.9930070217982951419344E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1024                             0                             0                             0                             0                             0                             0
 -0.7295874734841670261609E-01 -0.8350873084007630342551E-01  0.9279434015798599943992E+00  0.1561961812602287724694E+00  0.5517350488583739470672E-01 -0.9861838760182274343791E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1025                             0                             0                             0                             0                             0                             0
 -0.9696697282951015350871E-01 -0.8350873084007630342551E-01  0.9234937399986931083617E+00  0.2075949960051299003627E+00  0.5517350488583738776782E-01 -0.9766576687827945857379E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1026                             0                             0                             0                             0                             0                             0
 -0.1207094185781695666604E+00 -0.8350873084007630342551E-01  0.9177936830858279826373E+00  0.2584248072957321951115E+00  0.5517350488583738776782E-01 -0.9644545107638703429487E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1027                             0                             0                             0                             0                             0                             0
 -0.1441210082009152237958E+00 -0.8350873084007630342551E-01  0.9108588543010565086178E+00  0.3085462941524254598669E+00  0.5517350488583738776782E-01 -0.9496078499693533236936E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1028                             0                             0                             0                             0                             0                             0
 -0.1671375721579104189907E+00 -0.8350873084007630342551E-01  0.9027082615280439537031E+00  0.3578220770636364456152E+00  0.5517350488583738776782E-01 -0.9321583800645026895992E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1029                             0                             0                             0                             0                             0                             0
 -0.1896960236472111649420E+00 -0.8350873084007630342551E-01  0.8933642449750399672226E+00  0.4061170945335240145546E+00  0.5517350488583738776782E-01 -0.9121539288334297168603E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1030                             0                             0                             0                             0                             0                             0
 -0.2117345315213036704982E+00 -0.8350873084007630342551E-01  0.8828524159419220973533E+00  0.4532989732761479317880E+00  0.5517350488583738776782E-01 -0.8896493270864666014219E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1031                             0                             0                             0                             0                             0                             0
 -0.2331926897619830962860E+00 -0.8350873084007630342551E-01  0.8712015866214016801550E+00  0.4992383910414472381056E+00  0.5517350488583738082893E-01 -0.8647062583727260776101E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1032                             0                             0                             0                             0                             0                             0
 -0.2540116830490502519702E+00 -0.8350873084007630342551E-01  0.8584436911268069625436E+00  0.5438094310785374085881E+00  0.5517350488583738776782E-01 -0.8373930899097807856180E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1033                             0                             0                             0                             0                             0                             0
 -0.2741344479690153712603E+00 -0.8350873084007630342551E-01  0.8446136979628984242652E+00  0.5868899272647709608464E+00  0.5517350488583738776782E-01 -0.8077846851938730310394E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1034                             0                             0                             0                             0                             0                             0
 -0.2935058294219493046917E+00 -0.8350873084007630342551E-01  0.8297495141796271678203E+00  0.6283617989545905446747E+00  0.5517350488583738776782E-01 -0.7759621988042738616187E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1035                             0                             0                             0                             0                             0                             0
 -0.3120727317977778914049E+00 -0.8350873084007630342551E-01  0.8138918814715463412313E+00  0.6681113746303690703598E+00  0.5517350488583738776782E-01 -0.7420128539642231180196E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1036                             0                             0                             0                             0                             0                             0
 -0.3297842645076581868935E+00 -0.8350873084007630342551E-01  0.7970842645076582355657E+00  0.7060297034681376482368E+00  0.5517350488583738776782E-01 -0.7060297034681377592591E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1037                             0                             0                             0                             0                             0                             0
 -0.3465918814715461815368E+00 -0.8350873084007630342551E-01  0.7793727317977778845659E+00  0.7420128539642228959750E+00  0.5517350488583738082893E-01 -0.6681113746303691813822E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1038                             0                             0                             0                             0                             0                             0
 -0.3624495141796270636370E+00 -0.8350873084007630342551E-01  0.7608058294219495198973E+00  0.7759621988042735285518E+00  0.5517350488583738776782E-01 -0.6283617989545909887639E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1039                             0                             0                             0                             0                             0                             0
 -0.3773136979628984311042E+00 -0.8350873084007630342551E-01  0.7414344479690154754437E+00  0.8077846851938729200171E+00  0.5517350488583738776782E-01 -0.5868899272647711828910E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1040                             0                             0                             0                             0                             0                             0
 -0.3911436911268071359160E+00 -0.8350873084007630342551E-01  0.7213116830490502451312E+00  0.8373930899097810076626E+00  0.5517350488583738776782E-01 -0.5438094310785372975658E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1041                             0                             0                             0                             0                             0                             0
 -0.4039015866214015759716E+00 -0.8350873084007630342551E-01  0.7004926897619834225139E+00  0.8647062583727258555655E+00  0.5517350488583738776782E-01 -0.4992383910414477932171E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1042                             0                             0                             0                             0                             0                             0
 -0.4155524159419220486811E+00 -0.8350873084007630342551E-01  0.6790345315213037746815E+00  0.8896493270864664903996E+00  0.5517350488583738082893E-01 -0.4532989732761480983214E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1043                             0                             0                             0                             0                             0                             0
 -0.4260642449750398630393E+00 -0.8350873084007630342551E-01  0.6569960236472114356587E+00  0.9121539288334294948157E+00  0.5517350488583738776782E-01 -0.4061170945335245696661E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1044                             0                             0                             0                             0                             0                             0
 -0.4354082615280439605421E+00 -0.8350873084007630342551E-01  0.6344375721579103011294E+00  0.9321583800645028006215E+00  0.5517350488583739470672E-01 -0.3578220770636362235706E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1045                             0                             0                             0                             0                             0                             0
 -0.4435588543010565154567E+00 -0.8350873084007630342551E-01  0.6114210082009152724680E+00  0.9496078499693532126713E+00  0.5517350488583738082893E-01 -0.3085462941524256264003E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1046                             0                             0                             0                             0                             0                             0
 -0.4504936830858279894763E+00 -0.8350873084007630342551E-01  0.5880094185781696847215E+00  0.9644545107638702319264E+00  0.5517350488583738082893E-01 -0.2584248072957323616450E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1047                             0                             0                             0                             0                             0                             0
 -0.4561937399986930596896E+00 -0.8350873084007630342551E-01  0.5642669728295104381033E+00  0.9766576687827944747156E+00  0.5517350488583738776782E-01 -0.2075949960051305109854E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1048                             0                             0                             0                             0                             0                             0
 -0.4606434015798598902158E+00 -0.8350873084007630342551E-01  0.5402587473484168345550E+00  0.9861838760182273233568E+00  0.5517350488583738082893E-01 -0.1561961812602289390028E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1049                             0                             0                             0                             0                             0                             0
 -0.4638304716162265362023E+00 -0.8350873084007630342551E-01  0.5160505470121419246965E+00  0.9930070217982950309121E+00  0.5517350488583739470672E-01 -0.1043692436395574213437E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1050                             0                             0                             0                             0                             0                             0
 -0.4657462145703539779795E+00 -0.8350873084007630342551E-01  0.4917087248151148504149E+00  0.9971084043546855069096E+00  0.5517350488583739470672E-01 -0.5225623717668528150915E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1051                             0                             0                             0                             0                             0                             0
 -0.4663853795239664146166E+00 -0.8350873084007630342551E-01  0.4673000000000000486722E+00  0.9984767820828949203005E+00  0.5517350488583738776782E-01 -0.1222781395200766497891E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1052                             0                             0                             0                             0                             0                             0
 -0.4657462145703539224684E+00 -0.8350873084007630342551E-01  0.4428912751848848583514E+00  0.9971084043546853958873E+00  0.5517350488583738082893E-01  0.5225623717668591988739E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1053                             0                             0                             0                             0                             0                             0
 -0.4638304716162265917134E+00 -0.8350873084007630342551E-01  0.4185494529878586167371E+00  0.9930070217982951419344E+00  0.5517350488583739470672E-01  0.1043692436395563111207E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1054                             0                             0                             0                             0                             0                             0
 -0.4606434015798599457270E+00 -0.8350873084007630342551E-01  0.3943412526515833183005E+00  0.9861838760182274343791E+00  0.5517350488583739470672E-01  0.1561961812602286892027E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1055                             0                             0                             0                             0                             0                             0
 -0.4561937399986930596896E+00 -0.8350873084007630342551E-01  0.3703330271704896592411E+00  0.9766576687827944747156E+00  0.5517350488583738776782E-01  0.2075949960051302889408E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1056                             0                             0                             0                             0                             0                             0
 -0.4504936830858279339651E+00 -0.8350873084007630342551E-01  0.3465905814218300795559E+00  0.9644545107638701209041E+00  0.5517350488583739470672E-01  0.2584248072957329722676E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1057                             0                             0                             0                             0                             0                             0
 -0.4435588543010565709679E+00 -0.8350873084007630342551E-01  0.3231789917990848248763E+00  0.9496078499693533236936E+00  0.5517350488583738776782E-01  0.3085462941524254043557E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1058                             0                             0                             0                             0                             0                             0
 -0.4354082615280439605421E+00 -0.8350873084007630342551E-01  0.3001624278420897962150E+00  0.9321583800645028006215E+00  0.5517350488583738776782E-01  0.3578220770636360015260E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1059                             0                             0                             0                             0                             0                             0
 -0.4260642449750400850839E+00 -0.8350873084007630342551E-01  0.2776039763527889947525E+00  0.9121539288334299389049E+00  0.5517350488583738776782E-01  0.4061170945335235704654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1060                             0                             0                             0                             0                             0                             0
 -0.4155524159419221041922E+00 -0.8350873084007630342551E-01  0.2555654684786963226628E+00  0.8896493270864666014219E+00  0.5517350488583738776782E-01  0.4532989732761479317880E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1061                             0                             0                             0                             0                             0                             0
 -0.4039015866214016314828E+00 -0.8350873084007630342551E-01  0.2341073102380167303416E+00  0.8647062583727259665878E+00  0.5517350488583739470672E-01  0.4992383910414475711725E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1062                             0                             0                             0                             0                             0                             0
 -0.3911436911268071359160E+00 -0.8350873084007630342551E-01  0.2132883169509499077243E+00  0.8373930899097811186849E+00  0.5517350488583738776782E-01  0.5438094310785370755212E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1063                             0                             0                             0                             0                             0                             0
 -0.3773136979628985421265E+00 -0.8350873084007630342551E-01  0.1931655520309846219007E+00  0.8077846851938731420617E+00  0.5517350488583739470672E-01  0.5868899272647709608464E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1064                             0                             0                             0                             0                             0                             0
 -0.3624495141796273411927E+00 -0.8350873084007630342551E-01  0.1737941705780509105139E+00  0.7759621988042741946856E+00  0.5517350488583738776782E-01  0.6283617989545901005854E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1065                             0                             0                             0                             0                             0                             0
 -0.3465918814715461260256E+00 -0.8350873084007630342551E-01  0.1552272682022219907338E+00  0.7420128539642227849527E+00  0.5517350488583738776782E-01  0.6681113746303694034268E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1066                             0                             0                             0                             0                             0                             0
 -0.3297842645076582979158E+00 -0.8350873084007630342551E-01  0.1375157354923418062675E+00  0.7060297034681378702814E+00  0.5517350488583738776782E-01  0.7060297034681376482368E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1067                             0                             0                             0                             0                             0                             0
 -0.3120727317977778358937E+00 -0.8350873084007630342551E-01  0.1207081185284536450908E+00  0.6681113746303689593375E+00  0.5517350488583738776782E-01  0.7420128539642232290419E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1068                             0                             0                             0                             0                             0                             0
 -0.2935058294219495822475E+00 -0.8350873084007630342551E-01  0.1048504858203729850352E+00  0.6283617989545910997862E+00  0.5517350488583738776782E-01  0.7759621988042734175295E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1069                             0                             0                             0                             0                             0                             0
 -0.2741344479690154822826E+00 -0.8350873084007630342551E-01  0.8998630203710156205688E-01  0.5868899272647711828910E+00  0.5517350488583738776782E-01  0.8077846851938729200171E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1070                             0                             0                             0                             0                             0                             0
 -0.2540116830490505295259E+00 -0.8350873084007630342551E-01  0.7615630887319313480077E-01  0.5438094310785380747220E+00  0.5517350488583738776782E-01  0.8373930899097804525510E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1071                             0                             0                             0                             0                             0                             0
 -0.2331926897619830130193E+00 -0.8350873084007630342551E-01  0.6339841337859825065593E-01  0.4992383910414470715722E+00  0.5517350488583738082893E-01  0.8647062583727261886324E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1072                             0                             0                             0                             0                             0                             0
 -0.2117345315213037537649E+00 -0.8350873084007630342551E-01  0.5174758405807794447995E-01  0.4532989732761481538326E+00  0.5517350488583738776782E-01  0.8896493270864664903996E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1073                             0                             0                             0                             0                             0                             0
 -0.1896960236472110816752E+00 -0.8350873084007630342551E-01  0.4123575502495996358832E-01  0.4061170945335238480212E+00  0.5517350488583738776782E-01  0.9121539288334298278826E+00
