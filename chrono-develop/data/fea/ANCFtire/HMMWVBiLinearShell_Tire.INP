  0.2618961912232615207863E+00 -0.1454899278762296632728E+00  0.2054038087767384168636E+00  0.1546475093264525479952E+00  0.9757911127481380120230E+00 -0.1546475093264525757508E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           377                             0                             0                             0                             0                             0                             0
  0.2752438591993348615539E+00 -0.1454899278762296632728E+00  0.2194693160087736738539E+00  0.1625291955708184354901E+00  0.9757911127481382340676E+00 -0.1463419450084395001532E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           378                             0                             0                             0                             0                             0                             0
  0.2878371028893088601208E+00 -0.1454899278762296632728E+00  0.2342141099191292485937E+00  0.1699654005873905415758E+00  0.9757911127481381230453E+00 -0.1376352675912621281729E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           379                             0                             0                             0                             0                             0                             0
  0.2996414050875750301195E+00 -0.1454899278762296632728E+00  0.2495977760525948385695E+00  0.1769357422551027514412E+00  0.9757911127481382340676E+00 -0.1285513414725273084738E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           380                             0                             0                             0                             0                             0                             0
  0.3106244110223148058303E+00 -0.1454899278762296632728E+00  0.2655781488496042896941E+00  0.1834211153519463843864E+00  0.9757911127481382340676E+00 -0.1191150650623104545467E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           381                             0                             0                             0                             0                             0                             0
  0.3207560170376804742354E+00 -0.1454899278762296632728E+00  0.2821114272191029836989E+00  0.1894037439210557172142E+00  0.9757911127481380120230E+00 -0.1093523025383444646774E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           382                             0                             0                             0                             0                             0                             0
  0.3300084531058232739653E+00 -0.1454899278762296632728E+00  0.2991522945942942657283E+00  0.1948672299933702778407E+00  0.9757911127481382340676E+00 -0.9928981295410621576991E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           383                             0                             0                             0                             0                             0                             0
  0.3383563589426092921286E+00 -0.1454899278762296632728E+00  0.3166540431421988044391E+00  0.1997965985333280680702E+00  0.9757911127481382340676E+00 -0.8895517689411108763764E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           384                             0                             0                             0                             0                             0                             0
  0.3457768535183958213963E+00 -0.1454899278762296632728E+00  0.3345687017865786039295E+00  0.2041783384843973148115E+00  0.9757911127481381230453E+00 -0.7837672087744769477968E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           385                             0                             0                             0                             0                             0                             0
  0.3522495977733428040857E+00 -0.1454899278762296632728E+00  0.3528471676933220280148E+00  0.2080004398019431322009E+00  0.9757911127481381230453E+00 -0.6758343971675827288603E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           386                             0                             0                             0                             0                             0                             0
  0.3577568503653624221172E+00 -0.1454899278762296632728E+00  0.3714393408578991473412E+00  0.2112524263719251227389E+00  0.9757911127481381230453E+00 -0.5660491704547252617141E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           387                             0                             0                             0                             0                             0                             0
  0.3622835162979043399645E+00 -0.1454899278762296632728E+00  0.3902942614259921061404E+00  0.2139253847251977869171E+00  0.9757911127481381230453E+00 -0.4547124423112467589414E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           388                             0                             0                             0                             0                             0                             0
  0.3658171882942921060433E+00 -0.1454899278762296632728E+00  0.4093602493709130318855E+00  0.2160119884687098368303E+00  0.9757911127481382340676E+00 -0.3421293789700679405241E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           389                             0                             0                             0                             0                             0                             0
  0.3683481808052062600467E+00 -0.1454899278762296632728E+00  0.4285850461449656756407E+00  0.2175065183666383683558E+00  0.9757911127481379010007E+00 -0.2286085627822532009845E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           390                             0                             0                             0                             0                             0                             0
  0.3698695565561014308997E+00 -0.1454899278762296632728E+00  0.4479159579164915805372E+00  0.2184048780164166703166E+00  0.9757911127481380120230E+00 -0.1144611464142387090293E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           391                             0                             0                             0                             0                             0                             0
  0.3703771455617940189242E+00 -0.1454899278762296632728E+00  0.4672999999999999376499E+00  0.2187046050766889293548E+00  0.9757911127481381230453E+00 -0.4856217762953838986802E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           392                             0                             0                             0                             0                             0                             0
  0.3698695565561014308997E+00 -0.1454899278762296632728E+00  0.4866840420835084057849E+00  0.2184048780164166703166E+00  0.9757911127481380120230E+00  0.1144611464142387090293E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           393                             0                             0                             0                             0                             0                             0
  0.3683481808052062600467E+00 -0.1454899278762296632728E+00  0.5060149538550342551702E+00  0.2175065183666383683558E+00  0.9757911127481379010007E+00  0.2286085627822532009845E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           394                             0                             0                             0                             0                             0                             0
  0.3658171882942921060433E+00 -0.1454899278762296632728E+00  0.5252397506290870099477E+00  0.2160119884687098368303E+00  0.9757911127481382340676E+00  0.3421293789700679405241E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           395                             0                             0                             0                             0                             0                             0
  0.3622835162979042844533E+00 -0.1454899278762296632728E+00  0.5443057385740079912040E+00  0.2139253847251977591615E+00  0.9757911127481380120230E+00  0.4547124423112472446640E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           396                             0                             0                             0                             0                             0                             0
  0.3577568503653624221172E+00 -0.1454899278762296632728E+00  0.5631606591421007834697E+00  0.2112524263719251227389E+00  0.9757911127481381230453E+00  0.5660491704547252617141E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           397                             0                             0                             0                             0                             0                             0
  0.3522495977733428040857E+00 -0.1454899278762296632728E+00  0.5817528323066779583073E+00  0.2080004398019431322009E+00  0.9757911127481381230453E+00  0.6758343971675827288603E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           398                             0                             0                             0                             0                             0                             0
  0.3457768535183958213963E+00 -0.1454899278762296632728E+00  0.6000312982134213823926E+00  0.2041783384843973148115E+00  0.9757911127481381230453E+00  0.7837672087744769477968E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           399                             0                             0                             0                             0                             0                             0
  0.3383563589426093476398E+00 -0.1454899278762296632728E+00  0.6179459568578010708606E+00  0.1997965985333280958258E+00  0.9757911127481382340676E+00  0.8895517689411105988206E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           400                             0                             0                             0                             0                             0                             0
  0.3300084531058232739653E+00 -0.1454899278762296632728E+00  0.6354477054057057205938E+00  0.1948672299933702778407E+00  0.9757911127481382340676E+00  0.9928981295410621576991E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           401                             0                             0                             0                             0                             0                             0
  0.3207560170376804742354E+00 -0.1454899278762296632728E+00  0.6524885727808968916008E+00  0.1894037439210557449698E+00  0.9757911127481381230453E+00  0.1093523025383444230441E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           402                             0                             0                             0                             0                             0                             0
  0.3106244110223148058303E+00 -0.1454899278762296632728E+00  0.6690218511503955856057E+00  0.1834211153519464121420E+00  0.9757911127481380120230E+00  0.1191150650623103990355E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           403                             0                             0                             0                             0                             0                             0
  0.2996414050875750301195E+00 -0.1454899278762296632728E+00  0.6850022239474051755082E+00  0.1769357422551027514412E+00  0.9757911127481382340676E+00  0.1285513414725273084738E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           404                             0                             0                             0                             0                             0                             0
  0.2878371028893089156320E+00 -0.1454899278762296632728E+00  0.7003858900808707099728E+00  0.1699654005873905693313E+00  0.9757911127481382340676E+00  0.1376352675912621004173E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           405                             0                             0                             0                             0                             0                             0
  0.2752438591993349170650E+00 -0.1454899278762296632728E+00  0.7151306839912262569570E+00  0.1625291955708184632456E+00  0.9757911127481382340676E+00  0.1463419450084394446421E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           406                             0                             0                             0                             0                             0                             0
  0.2618961912232615762974E+00 -0.1454899278762296632728E+00  0.7291961912232615139473E+00  0.1546475093264525757508E+00  0.9757911127481380120230E+00  0.1546475093264525479952E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           407                             0                             0                             0                             0                             0                             0
  0.2478306839912263748182E+00 -0.1454899278762296632728E+00  0.7425438591993347436926E+00  0.1463419450084395001532E+00  0.9757911127481380120230E+00  0.1625291955708184077345E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           408                             0                             0                             0                             0                             0                             0
  0.2330858900808707445673E+00 -0.1454899278762296632728E+00  0.7551371028893087977707E+00  0.1376352675912621281729E+00  0.9757911127481381230453E+00  0.1699654005873905415758E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           409                             0                             0                             0                             0                             0                             0
  0.2177022239474051545916E+00 -0.1454899278762296632728E+00  0.7669414050875750232805E+00  0.1285513414725273084738E+00  0.9757911127481382340676E+00  0.1769357422551027514412E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           410                             0                             0                             0                             0                             0                             0
  0.2017218511503957589781E+00 -0.1454899278762296632728E+00  0.7779244110223146879690E+00  0.1191150650623104823023E+00  0.9757911127481382340676E+00  0.1834211153519463566308E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           411                             0                             0                             0                             0                             0                             0
  0.1851885727808969817065E+00 -0.1454899278762296632728E+00  0.7880560170376804673964E+00  0.1093523025383444369218E+00  0.9757911127481381230453E+00  0.1894037439210557449698E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           412                             0                             0                             0                             0                             0                             0
  0.1681477054057057274328E+00 -0.1454899278762296632728E+00  0.7973084531058232116152E+00  0.9928981295410622964770E-01  0.9757911127481380120230E+00  0.1948672299933702500851E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           413                             0                             0                             0                             0                             0                             0
  0.1506459568578010221884E+00 -0.1454899278762296632728E+00  0.8056563589426093408008E+00  0.8895517689411101824870E-01  0.9757911127481381230453E+00  0.1997965985333280958258E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           414                             0                             0                             0                             0                             0                             0
  0.1327312982134212782093E+00 -0.1454899278762296632728E+00  0.8130768535183958700685E+00  0.7837672087744765314632E-01  0.9757911127481380120230E+00  0.2041783384843973148115E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           415                             0                             0                             0                             0                             0                             0
  0.1144528323066779929018E+00 -0.1454899278762296632728E+00  0.8195495977733427972467E+00  0.6758343971675828676382E-01  0.9757911127481381230453E+00  0.2080004398019431322009E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           416                             0                             0                             0                             0                             0                             0
  0.9586065914210077643087E-01 -0.1454899278762296632728E+00  0.8250568503653623597671E+00  0.5660491704547249147694E-01  0.9757911127481380120230E+00  0.2112524263719251227389E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           417                             0                             0                             0                             0                             0                             0
  0.7700573857400792865402E-01 -0.1454899278762296632728E+00  0.8295835162979043886367E+00  0.4547124423112468283303E-01  0.9757911127481382340676E+00  0.2139253847251977869171E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           418                             0                             0                             0                             0                             0                             0
  0.5793975062908698903108E-01 -0.1454899278762296632728E+00  0.8331171882942920436932E+00  0.3421293789700680793020E-01  0.9757911127481382340676E+00  0.2160119884687098368303E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           419                             0                             0                             0                             0                             0                             0
  0.3871495385503424119245E-01 -0.1454899278762296632728E+00  0.8356481808052063087189E+00  0.2286085627822528540398E-01  0.9757911127481381230453E+00  0.2175065183666383961114E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           420                             0                             0                             0                             0                             0                             0
  0.1938404208350845772668E-01 -0.1454899278762296632728E+00  0.8371695565561014795719E+00  0.1144611464142388478071E-01  0.9757911127481380120230E+00  0.2184048780164166703166E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           421                             0                             0                             0                             0                             0                             0
  0.1871595532085379537444E-15 -0.1454899278762296632728E+00  0.8376771455617939565741E+00  0.1105161499873744386723E-15  0.9757911127481381230453E+00  0.2187046050766889293548E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           422                             0                             0                             0                             0                             0                             0
 -0.1938404208350841262387E-01 -0.1454899278762296632728E+00  0.8371695565561014795719E+00 -0.1144611464142385702514E-01  0.9757911127481380120230E+00  0.2184048780164166703166E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           423                             0                             0                             0                             0                             0                             0
 -0.3871495385503419262019E-01 -0.1454899278762296632728E+00  0.8356481808052063087189E+00 -0.2286085627822525764841E-01  0.9757911127481381230453E+00  0.2175065183666383961114E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           424                             0                             0                             0                             0                             0                             0
 -0.5793975062908694739772E-01 -0.1454899278762296632728E+00  0.8331171882942920436932E+00 -0.3421293789700678017462E-01  0.9757911127481381230453E+00  0.2160119884687098368303E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           425                             0                             0                             0                             0                             0                             0
 -0.7700573857400788702066E-01 -0.1454899278762296632728E+00  0.8295835162979043886367E+00 -0.4547124423112466201635E-01  0.9757911127481381230453E+00  0.2139253847251977869171E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           426                             0                             0                             0                             0                             0                             0
 -0.9586065914210073479751E-01 -0.1454899278762296632728E+00  0.8250568503653624707894E+00 -0.5660491704547246372137E-01  0.9757911127481382340676E+00  0.2112524263719251504945E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           427                             0                             0                             0                             0                             0                             0
 -0.1144528323066779512684E+00 -0.1454899278762296632728E+00  0.8195495977733429082690E+00 -0.6758343971675825900824E-01  0.9757911127481382340676E+00  0.2080004398019431599565E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           428                             0                             0                             0                             0                             0                             0
 -0.1327312982134212504537E+00 -0.1454899278762296632728E+00  0.8130768535183958700685E+00 -0.7837672087744762539074E-01  0.9757911127481381230453E+00  0.2041783384843973425671E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           429                             0                             0                             0                             0                             0                             0
 -0.1506459568578011332107E+00 -0.1454899278762296632728E+00  0.8056563589426093408008E+00 -0.8895517689411107375985E-01  0.9757911127481381230453E+00  0.1997965985333280680702E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           430                             0                             0                             0                             0                             0                             0
 -0.1681477054057056996772E+00 -0.1454899278762296632728E+00  0.7973084531058232116152E+00 -0.9928981295410620189212E-01  0.9757911127481381230453E+00  0.1948672299933702778407E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           431                             0                             0                             0                             0                             0                             0
 -0.1851885727808969261954E+00 -0.1454899278762296632728E+00  0.7880560170376804673964E+00 -0.1093523025383444230441E+00  0.9757911127481380120230E+00  0.1894037439210557449698E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           432                             0                             0                             0                             0                             0                             0
 -0.2017218511503957034670E+00 -0.1454899278762296632728E+00  0.7779244110223146879690E+00 -0.1191150650623104545467E+00  0.9757911127481380120230E+00  0.1834211153519463566308E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           433                             0                             0                             0                             0                             0                             0
 -0.2177022239474050990804E+00 -0.1454899278762296632728E+00  0.7669414050875750232805E+00 -0.1285513414725272807182E+00  0.9757911127481380120230E+00  0.1769357422551027514412E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           434                             0                             0                             0                             0                             0                             0
 -0.2330858900808707168117E+00 -0.1454899278762296632728E+00  0.7551371028893089087930E+00 -0.1376352675912621004173E+00  0.9757911127481382340676E+00  0.1699654005873905693313E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           435                             0                             0                             0                             0                             0                             0
 -0.2478306839912263193071E+00 -0.1454899278762296632728E+00  0.7425438591993348547149E+00 -0.1463419450084395001532E+00  0.9757911127481382340676E+00  0.1625291955708184354901E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           436                             0                             0                             0                             0                             0                             0
 -0.2618961912232615207863E+00 -0.1454899278762296632728E+00  0.7291961912232616249696E+00 -0.1546475093264525479952E+00  0.9757911127481380120230E+00  0.1546475093264525757508E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           437                             0                             0                             0                             0                             0                             0
 -0.2752438591993347505316E+00 -0.1454899278762296632728E+00  0.7151306839912263679793E+00 -0.1625291955708183799789E+00  0.9757911127481380120230E+00  0.1463419450084395001532E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           438                             0                             0                             0                             0                             0                             0
 -0.2878371028893088046097E+00 -0.1454899278762296632728E+00  0.7003858900808708209951E+00 -0.1699654005873904860646E+00  0.9757911127481382340676E+00  0.1376352675912622114396E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           439                             0                             0                             0                             0                             0                             0
 -0.2996414050875749746083E+00 -0.1454899278762296632728E+00  0.6850022239474051755082E+00 -0.1769357422551027236857E+00  0.9757911127481380120230E+00  0.1285513414725273362293E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           440                             0                             0                             0                             0                             0                             0
 -0.3106244110223148058303E+00 -0.1454899278762296632728E+00  0.6690218511503956966280E+00 -0.1834211153519464121420E+00  0.9757911127481382340676E+00  0.1191150650623104267911E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           441                             0                             0                             0                             0                             0                             0
 -0.3207560170376804187242E+00 -0.1454899278762296632728E+00  0.6524885727808971136454E+00 -0.1894037439210556894587E+00  0.9757911127481381230453E+00  0.1093523025383445340664E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           442                             0                             0                             0                             0                             0                             0
 -0.3300084531058232184542E+00 -0.1454899278762296632728E+00  0.6354477054057057205938E+00 -0.1948672299933702500851E+00  0.9757911127481380120230E+00  0.9928981295410624352549E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           443                             0                             0                             0                             0                             0                             0
 -0.3383563589426092366175E+00 -0.1454899278762296632728E+00  0.6179459568578012929052E+00 -0.1997965985333280403147E+00  0.9757911127481381230453E+00  0.8895517689411119865994E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           444                             0                             0                             0                             0                             0                             0
 -0.3457768535183959324186E+00 -0.1454899278762296632728E+00  0.6000312982134211603480E+00 -0.2041783384843973703227E+00  0.9757911127481382340676E+00  0.7837672087744758375738E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           445                             0                             0                             0                             0                             0                             0
 -0.3522495977733428040857E+00 -0.1454899278762296632728E+00  0.5817528323066780693296E+00 -0.2080004398019431322009E+00  0.9757911127481381230453E+00  0.6758343971675830064161E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           446                             0                             0                             0                             0                             0                             0
 -0.3577568503653624221172E+00 -0.1454899278762296632728E+00  0.5631606591421007834697E+00 -0.2112524263719251227389E+00  0.9757911127481381230453E+00  0.5660491704547249841584E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           447                             0                             0                             0                             0                             0                             0
 -0.3622835162979042844533E+00 -0.1454899278762296632728E+00  0.5443057385740081022263E+00 -0.2139253847251977591615E+00  0.9757911127481381230453E+00  0.4547124423112479385534E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           448                             0                             0                             0                             0                             0                             0
 -0.3658171882942921060433E+00 -0.1454899278762296632728E+00  0.5252397506290870099477E+00 -0.2160119884687098090748E+00  0.9757911127481380120230E+00  0.3421293789700681486909E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           449                             0                             0                             0                             0                             0                             0
 -0.3683481808052062600467E+00 -0.1454899278762296632728E+00  0.5060149538550345882371E+00 -0.2175065183666383683558E+00  0.9757911127481381230453E+00  0.2286085627822549357080E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           450                             0                             0                             0                             0                             0                             0
 -0.3698695565561014864109E+00 -0.1454899278762296632728E+00  0.4866840420835082947626E+00 -0.2184048780164166980722E+00  0.9757911127481381230453E+00  0.1144611464142380151399E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           451                             0                             0                             0                             0                             0                             0
 -0.3703771455617940189242E+00 -0.1454899278762296632728E+00  0.4673000000000000486722E+00 -0.2187046050766889293548E+00  0.9757911127481381230453E+00  0.2678358945659530862813E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           452                             0                             0                             0                             0                             0                             0
 -0.3698695565561014308997E+00 -0.1454899278762296632728E+00  0.4479159579164914140037E+00 -0.2184048780164166703166E+00  0.9757911127481380120230E+00 -0.1144611464142394029186E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           453                             0                             0                             0                             0                             0                             0
 -0.3683481808052062600467E+00 -0.1454899278762296632728E+00  0.4285850461449658421742E+00 -0.2175065183666383961114E+00  0.9757911127481381230453E+00 -0.2286085627822524724007E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           454                             0                             0                             0                             0                             0                             0
 -0.3658171882942921060433E+00 -0.1454899278762296632728E+00  0.4093602493709130873967E+00 -0.2160119884687098368303E+00  0.9757911127481381230453E+00 -0.3421293789700675935794E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           455                             0                             0                             0                             0                             0                             0
 -0.3622835162979042844533E+00 -0.1454899278762296632728E+00  0.3902942614259919951181E+00 -0.2139253847251977591615E+00  0.9757911127481381230453E+00 -0.4547124423112474528308E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           456                             0                             0                             0                             0                             0                             0
 -0.3577568503653623666061E+00 -0.1454899278762296632728E+00  0.3714393408578989808078E+00 -0.2112524263719250949833E+00  0.9757911127481381230453E+00 -0.5660491704547263719371E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           457                             0                             0                             0                             0                             0                             0
 -0.3522495977733428595968E+00 -0.1454899278762296632728E+00  0.3528471676933220280148E+00 -0.2080004398019431599565E+00  0.9757911127481381230453E+00 -0.6758343971675824513046E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           458                             0                             0                             0                             0                             0                             0
 -0.3457768535183959324186E+00 -0.1454899278762296632728E+00  0.3345687017865789369964E+00 -0.2041783384843973703227E+00  0.9757911127481380120230E+00 -0.7837672087744752824623E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           459                             0                             0                             0                             0                             0                             0
 -0.3383563589426094031509E+00 -0.1454899278762296632728E+00  0.3166540431421990264838E+00 -0.1997965985333281235814E+00  0.9757911127481381230453E+00 -0.8895517689411097661534E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           460                             0                             0                             0                             0                             0                             0
 -0.3300084531058232739653E+00 -0.1454899278762296632728E+00  0.2991522945942942657283E+00 -0.1948672299933702778407E+00  0.9757911127481381230453E+00 -0.9928981295410620189212E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           461                             0                             0                             0                             0                             0                             0
 -0.3207560170376804742354E+00 -0.1454899278762296632728E+00  0.2821114272191029836989E+00 -0.1894037439210557172142E+00  0.9757911127481381230453E+00 -0.1093523025383444924330E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           462                             0                             0                             0                             0                             0                             0
 -0.3106244110223148613414E+00 -0.1454899278762296632728E+00  0.2655781488496044007164E+00 -0.1834211153519464121420E+00  0.9757911127481381230453E+00 -0.1191150650623103851578E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           463                             0                             0                             0                             0                             0                             0
 -0.2996414050875750301195E+00 -0.1454899278762296632728E+00  0.2495977760525948940806E+00 -0.1769357422551027791968E+00  0.9757911127481382340676E+00 -0.1285513414725272807182E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           464                             0                             0                             0                             0                             0                             0
 -0.2878371028893090266543E+00 -0.1454899278762296632728E+00  0.2342141099191294428827E+00 -0.1699654005873906248425E+00  0.9757911127481380120230E+00 -0.1376352675912620171506E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           465                             0                             0                             0                             0                             0                             0
 -0.2752438591993347505316E+00 -0.1454899278762296632728E+00  0.2194693160087735350761E+00 -0.1625291955708183522233E+00  0.9757911127481380120230E+00 -0.1463419450084395556644E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           466                             0                             0                             0                             0                             0                             0
 -0.2618961912232615762974E+00 -0.1454899278762296632728E+00  0.2054038087767384723747E+00 -0.1546475093264526035064E+00  0.9757911127481382340676E+00 -0.1546475093264525479952E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           467                             0                             0                             0                             0                             0                             0
 -0.2478306839912262915515E+00 -0.1454899278762296632728E+00  0.1920561408006650760960E+00 -0.1463419450084394723977E+00  0.9757911127481382340676E+00 -0.1625291955708184632456E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           468                             0                             0                             0                             0                             0                             0
 -0.2330858900808709111008E+00 -0.1454899278762296632728E+00  0.1794628971106912440625E+00 -0.1376352675912622391952E+00  0.9757911127481381230453E+00 -0.1699654005873904583090E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           469                             0                             0                             0                             0                             0                             0
 -0.2177022239474051823471E+00 -0.1454899278762296632728E+00  0.1676585949124250185527E+00 -0.1285513414725273362293E+00  0.9757911127481380120230E+00 -0.1769357422551027236857E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           470                             0                             0                             0                             0                             0                             0
 -0.2017218511503959532671E+00 -0.1454899278762296632728E+00  0.1566755889776853538642E+00 -0.1191150650623105933246E+00  0.9757911127481382340676E+00 -0.1834211153519462733641E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           471                             0                             0                             0                             0                             0                             0
 -0.1851885727808968706842E+00 -0.1454899278762296632728E+00  0.1465439829623194634145E+00 -0.1093523025383443814107E+00  0.9757911127481381230453E+00 -0.1894037439210557449698E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           472                             0                             0                             0                             0                             0                             0
 -0.1681477054057057829439E+00 -0.1454899278762296632728E+00  0.1372915468941767747069E+00 -0.9928981295410625740328E-01  0.9757911127481381230453E+00 -0.1948672299933702500851E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           473                             0                             0                             0                             0                             0                             0
 -0.1506459568578010776996E+00 -0.1454899278762296632728E+00  0.1289436410573906455213E+00 -0.8895517689411104600428E-01  0.9757911127481382340676E+00 -0.1997965985333280958258E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           474                             0                             0                             0                             0                             0                             0
 -0.1327312982134215002539E+00 -0.1454899278762296632728E+00  0.1215231464816042272759E+00 -0.7837672087744777804641E-01  0.9757911127481381230453E+00 -0.2041783384843972870559E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           475                             0                             0                             0                             0                             0                             0
 -0.1144528323066780345352E+00 -0.1454899278762296632728E+00  0.1150504022266571890754E+00 -0.6758343971675831451940E-01  0.9757911127481382340676E+00 -0.2080004398019431322009E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           476                             0                             0                             0                             0                             0                             0
 -0.9586065914210081806424E-01 -0.1454899278762296632728E+00  0.1095431496346375710438E+00 -0.5660491704547251229362E-01  0.9757911127481381230453E+00 -0.2112524263719251227389E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           477                             0                             0                             0                             0                             0                             0
 -0.7700573857400781763172E-01 -0.1454899278762296632728E+00  0.1050164837020956531966E+00 -0.4547124423112462038299E-01  0.9757911127481380120230E+00 -0.2139253847251977869171E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           478                             0                             0                             0                             0                             0                             0
 -0.5793975062908703066444E-01 -0.1454899278762296632728E+00  0.1014828117057078871177E+00 -0.3421293789700682874688E-01  0.9757911127481380120230E+00 -0.2160119884687098090748E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           479                             0                             0                             0                             0                             0                             0
 -0.3871495385503428976470E-01 -0.1454899278762296632728E+00  0.9895181919479373311432E-01 -0.2286085627822531315956E-01  0.9757911127481381230453E+00 -0.2175065183666383961114E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           480                             0                             0                             0                             0                             0                             0
 -0.1938404208350866589350E-01 -0.1454899278762296632728E+00  0.9743044344389856226130E-01 -0.1144611464142400621136E-01  0.9757911127481380120230E+00 -0.2184048780164166703166E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           481                             0                             0                             0                             0                             0                             0
  0.2478447034988451742687E-16 -0.1500082858934205787271E+00  0.6253888247386213405932E-01  0.1492889658186007431175E-17  0.9997027456190183958284E+00 -0.2438073833574570803417E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           482                             0                             0                             0                             0                             0                             0
  0.2118356013569305112965E-01 -0.1500082858934205787271E+00  0.6309359351813154104249E-01  0.1275989254710253916272E-02  0.9997027456190182848061E+00 -0.2434732538119873876403E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           483                             0                             0                             0                             0                             0                             0
  0.4230905760550526806263E-01 -0.1500082858934205787271E+00  0.6475620622652494828841E-01  0.2548481111566265784607E-02  0.9997027456190182848061E+00 -0.2424717810014374169691E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           484                             0                             0                             0                             0                             0                             0
  0.6331858888928741657676E-01 -0.1500082858934205787271E+00  0.6752216349317535781793E-01  0.3813987758838229685798E-02  0.9997027456190185068508E+00 -0.2408057098931693992827E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           485                             0                             0                             0                             0                             0                             0
  0.8415456832214517068902E-01 -0.1500082858934205787271E+00  0.7138388402147433087208E-01  0.5069040530770257090010E-02  0.9997027456190183958284E+00 -0.2384796070722838140510E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           486                             0                             0                             0                             0                             0                             0
  0.1047598859327441706002E+00 -0.1500082858934205787271E+00  0.7633078310387858556041E-01  0.6310199414952124587208E-02  0.9997027456190183958284E+00 -0.2354998482249273661360E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           487                             0                             0                             0                             0                             0                             0
  0.1250780639777719915884E+00 -0.1500082858934205787271E+00  0.8234930163385811852095E-01  0.7534062481154197438160E-02  0.9997027456190182848061E+00 -0.2318746006629801223453E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           488                             0                             0                             0                             0                             0                             0
  0.1450534117435063607982E+00 -0.1500082858934205787271E+00  0.8942294327046423907390E-01  0.8737275205781687772988E-02  0.9997027456190183958284E+00 -0.2276138009380215473931E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           489                             0                             0                             0                             0                             0                             0
  0.1646311781901907411729E+00 -0.1500082858934205787271E+00  0.9753231965365383171473E-01  0.9916539666390680740626E-02  0.9997027456190183958284E+00 -0.2227291276059331637249E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           490                             0                             0                             0                             0                             0                             0
  0.1837577020208287503777E+00 -0.1500082858934205787271E+00  0.1066552035464364833750E+00  0.1106862358106432131510E-01  0.9997027456190182848061E+00 -0.2172339692167887456598E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           491                             0                             0                             0                             0                             0                             0
  0.2023805587630688740397E+00 -0.1500082858934205787271E+00  0.1167665897581858236443E+00  0.1219036916787285054764E-01  0.9997027456190183958284E+00 -0.2111433876177692264831E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           492                             0                             0                             0                             0                             0                             0
  0.2204487044610397017408E+00 -0.1500082858934205787271E+00  0.1278387636821294304212E+00  0.1327870180013441918365E-01  0.9997027456190183958284E+00 -0.2044740766696862693808E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           493                             0                             0                             0                             0                             0                             0
  0.2379126155832843036997E+00 -0.1500082858934205787271E+00  0.1398413772591590720218E+00  0.1433063843375306269101E-01  0.9997027456190185068508E+00 -0.1972443164902705145525E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           494                             0                             0                             0                             0                             0                             0
  0.2547244247633183023005E+00 -0.1500082858934205787271E+00  0.1527415321597516140173E+00  0.1534329578353525389001E-01  0.9997027456190183958284E+00 -0.1894739233496392505351E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           495                             0                             0                             0                             0                             0                             0
  0.2708380520007537262117E+00 -0.1500082858934205787271E+00  0.1665038699560032475766E+00  0.1631389822607418743639E-01  0.9997027456190181737838E+00 -0.1811841953552775774661E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           496                             0                             0                             0                             0                             0                             0
  0.2862093309633771953671E+00 -0.1500082858934205787271E+00  0.1810906690366227422828E+00  0.1723978540754060942430E-01  0.9997027456190183958284E+00 -0.1723978540754061289375E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           497                             0                             0                             0                             0                             0                             0
  0.3007961300439968010956E+00 -0.1500082858934205787271E+00  0.1964619479992462669493E+00  0.1811841953552776121605E-01  0.9997027456190183958284E+00 -0.1631389822607418743639E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           498                             0                             0                             0                             0                             0                             0
  0.3145584678402483791437E+00 -0.1500082858934205787271E+00  0.2125755752366817463717E+00  0.1894739233496392852296E-01  0.9997027456190183958284E+00 -0.1534329578353525042056E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           499                             0                             0                             0                             0                             0                             0
  0.3274586227408409211392E+00 -0.1500082858934205787271E+00  0.2293873844167156894613E+00  0.1972443164902705145525E-01  0.9997027456190185068508E+00 -0.1433063843375306269101E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           500                             0                             0                             0                             0                             0                             0
  0.3394612363178705627398E+00 -0.1500082858934205787271E+00  0.2468512955389602914202E+00  0.2044740766696862693808E-01  0.9997027456190183958284E+00 -0.1327870180013441918365E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           501                             0                             0                             0                             0                             0                             0
  0.3505334102418141695168E+00 -0.1500082858934205787271E+00  0.2649194412369310636102E+00  0.2111433876177691917886E-01  0.9997027456190183958284E+00 -0.1219036916787285401709E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           502                             0                             0                             0                             0                             0                             0
  0.3606447964535635652972E+00 -0.1500082858934205787271E+00  0.2835422979791712427833E+00  0.2172339692167887803542E-01  0.9997027456190183958284E+00 -0.1106862358106431958038E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           503                             0                             0                             0                             0                             0                             0
  0.3697676803463461614463E+00 -0.1500082858934205787271E+00  0.3026688218098091964769E+00  0.2227291276059331637249E-01  0.9997027456190185068508E+00 -0.9916539666390684210073E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           504                             0                             0                             0                             0                             0                             0
  0.3778770567295357540871E+00 -0.1500082858934205787271E+00  0.3222465882564936601185E+00  0.2276138009380215473931E-01  0.9997027456190183958284E+00 -0.8737275205781687772988E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           505                             0                             0                             0                             0                             0                             0
  0.3849506983661418746401E+00 -0.1500082858934205787271E+00  0.3422219360222280570838E+00  0.2318746006629801223453E-01  0.9997027456190182848061E+00 -0.7534062481154195703437E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           506                             0                             0                             0                             0                             0                             0
  0.3909692168961214076006E+00 -0.1500082858934205787271E+00  0.3625401140672558364386E+00  0.2354998482249273661360E-01  0.9997027456190183958284E+00 -0.6310199414952123719846E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           507                             0                             0                             0                             0                             0                             0
  0.3959161159785257178001E+00 -0.1500082858934205787271E+00  0.3831454316778549196165E+00  0.2384796070722838140510E-01  0.9997027456190185068508E+00 -0.5069040530770250151116E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           508                             0                             0                             0                             0                             0                             0
  0.3997778365068246353431E+00 -0.1500082858934205787271E+00  0.4039814111107126182176E+00  0.2408057098931693992827E-01  0.9997027456190185068508E+00 -0.3813987758838228384756E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           509                             0                             0                             0                             0                             0                             0
  0.4025437937734750448726E+00 -0.1500082858934205787271E+00  0.4249909423944947528540E+00  0.2424717810014374169691E-01  0.9997027456190182848061E+00 -0.2548481111566264049884E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           510                             0                             0                             0                             0                             0                             0
  0.4042064064818684521185E+00 -0.1500082858934205787271E+00  0.4461164398643070461148E+00  0.2434732538119873876403E-01  0.9997027456190182848061E+00 -0.1275989254710246977378E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           511                             0                             0                             0                             0                             0                             0
  0.4047611175261378591017E+00 -0.1500082858934205787271E+00  0.4672999999999998821387E+00  0.2438073833574570803417E-01  0.9997027456190183958284E+00 -0.5413611411541221059934E-17
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           512                             0                             0                             0                             0                             0                             0
  0.4042064064818684521185E+00 -0.1500082858934205787271E+00  0.4884835601356929402073E+00  0.2434732538119873876403E-01  0.9997027456190182848061E+00  0.1275989254710246977378E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           513                             0                             0                             0                             0                             0                             0
  0.4025437937734750448726E+00 -0.1500082858934205787271E+00  0.5096090576055052334681E+00  0.2424717810014374169691E-01  0.9997027456190182848061E+00  0.2548481111566264049884E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           514                             0                             0                             0                             0                             0                             0
  0.3997778365068246353431E+00 -0.1500082858934205787271E+00  0.5306185888892873681044E+00  0.2408057098931693992827E-01  0.9997027456190185068508E+00  0.3813987758838228384756E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           515                             0                             0                             0                             0                             0                             0
  0.3959161159785256622889E+00 -0.1500082858934205787271E+00  0.5514545683221451222167E+00  0.2384796070722838140510E-01  0.9997027456190183958284E+00  0.5069040530770255355286E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           516                             0                             0                             0                             0                             0                             0
  0.3909692168961214076006E+00 -0.1500082858934205787271E+00  0.5720598859327441498834E+00  0.2354998482249273661360E-01  0.9997027456190183958284E+00  0.6310199414952123719846E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           517                             0                             0                             0                             0                             0                             0
  0.3849506983661418746401E+00 -0.1500082858934205787271E+00  0.5923780639777719292383E+00  0.2318746006629801223453E-01  0.9997027456190182848061E+00  0.7534062481154195703437E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           518                             0                             0                             0                             0                             0                             0
  0.3778770567295357540871E+00 -0.1500082858934205787271E+00  0.6123534117435063262036E+00  0.2276138009380215473931E-01  0.9997027456190183958284E+00  0.8737275205781687772988E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           519                             0                             0                             0                             0                             0                             0
  0.3697676803463462169574E+00 -0.1500082858934205787271E+00  0.6319311781901907343340E+00  0.2227291276059331984194E-01  0.9997027456190186178731E+00  0.9916539666390680740626E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           520                             0                             0                             0                             0                             0                             0
  0.3606447964535635652972E+00 -0.1500082858934205787271E+00  0.6510577020208287990499E+00  0.2172339692167887803542E-01  0.9997027456190183958284E+00  0.1106862358106431958038E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           521                             0                             0                             0                             0                             0                             0
  0.3505334102418141695168E+00 -0.1500082858934205787271E+00  0.6696805587630688672007E+00  0.2111433876177692264831E-01  0.9997027456190182848061E+00  0.1219036916787285054764E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           522                             0                             0                             0                             0                             0                             0
  0.3394612363178706182509E+00 -0.1500082858934205787271E+00  0.6877487044610395283684E+00  0.2044740766696862693808E-01  0.9997027456190183958284E+00  0.1327870180013441397948E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           523                             0                             0                             0                             0                             0                             0
  0.3274586227408409211392E+00 -0.1500082858934205787271E+00  0.7052126155832842968607E+00  0.1972443164902705145525E-01  0.9997027456190185068508E+00  0.1433063843375306269101E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           524                             0                             0                             0                             0                             0                             0
  0.3145584678402484346549E+00 -0.1500082858934205787271E+00  0.7220244247633182954615E+00  0.1894739233496392852296E-01  0.9997027456190183958284E+00  0.1534329578353524868584E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           525                             0                             0                             0                             0                             0                             0
  0.3007961300439968566067E+00 -0.1500082858934205787271E+00  0.7381380520007536638616E+00  0.1811841953552776468550E-01  0.9997027456190185068508E+00  0.1631389822607418049749E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           526                             0                             0                             0                             0                             0                             0
  0.2862093309633772508782E+00 -0.1500082858934205787271E+00  0.7535093309633771330169E+00  0.1723978540754061289375E-01  0.9997027456190183958284E+00  0.1723978540754060942430E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           527                             0                             0                             0                             0                             0                             0
  0.2708380520007537262117E+00 -0.1500082858934205787271E+00  0.7680961300439967942566E+00  0.1631389822607418743639E-01  0.9997027456190183958284E+00  0.1811841953552775774661E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           528                             0                             0                             0                             0                             0                             0
  0.2547244247633182467894E+00 -0.1500082858934205787271E+00  0.7818584678402483723048E+00  0.1534329578353525042056E-01  0.9997027456190183958284E+00  0.1894739233496392852296E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           529                             0                             0                             0                             0                             0                             0
  0.2379126155832843036997E+00 -0.1500082858934205787271E+00  0.7947586227408409698114E+00  0.1433063843375306269101E-01  0.9997027456190185068508E+00  0.1972443164902705145525E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           530                             0                             0                             0                             0                             0                             0
  0.2204487044610397294964E+00 -0.1500082858934205787271E+00  0.8067612363178704448785E+00  0.1327870180013442265310E-01  0.9997027456190182848061E+00  0.2044740766696862346863E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           531                             0                             0                             0                             0                             0                             0
  0.2023805587630688740397E+00 -0.1500082858934205787271E+00  0.8178334102418141071666E+00  0.1219036916787285054764E-01  0.9997027456190183958284E+00  0.2111433876177692264831E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           532                             0                             0                             0                             0                             0                             0
  0.1837577020208287503777E+00 -0.1500082858934205787271E+00  0.8279447964535635584582E+00  0.1106862358106432131510E-01  0.9997027456190182848061E+00  0.2172339692167887456598E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           533                             0                             0                             0                             0                             0                             0
  0.1646311781901906579062E+00 -0.1500082858934205787271E+00  0.8370676803463461546073E+00  0.9916539666390675536456E-02  0.9997027456190183958284E+00  0.2227291276059331984194E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           534                             0                             0                             0                             0                             0                             0
  0.1450534117435062775314E+00 -0.1500082858934205787271E+00  0.8451770567295358027593E+00  0.8737275205781682568817E-02  0.9997027456190182848061E+00  0.2276138009380215473931E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           535                             0                             0                             0                             0                             0                             0
  0.1250780639777719915884E+00 -0.1500082858934205787271E+00  0.8522506983661418678011E+00  0.7534062481154197438160E-02  0.9997027456190182848061E+00  0.2318746006629801223453E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           536                             0                             0                             0                             0                             0                             0
  0.1047598859327440873335E+00 -0.1500082858934205787271E+00  0.8582692168961214562728E+00  0.6310199414952119383038E-02  0.9997027456190182848061E+00  0.2354998482249273661360E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           537                             0                             0                             0                             0                             0                             0
  0.8415456832214508742229E-01 -0.1500082858934205787271E+00  0.8632161159785256554500E+00  0.5069040530770251018478E-02  0.9997027456190185068508E+00  0.2384796070722838140510E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           538                             0                             0                             0                             0                             0                             0
  0.6331858888928741657676E-01 -0.1500082858934205787271E+00  0.8670778365068245729930E+00  0.3813987758838229685798E-02  0.9997027456190185068508E+00  0.2408057098931693992827E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           539                             0                             0                             0                             0                             0                             0
  0.4230905760550517785701E-01 -0.1500082858934205787271E+00  0.8698437937734750935448E+00  0.2548481111566260146756E-02  0.9997027456190183958284E+00  0.2424717810014374516636E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           540                             0                             0                             0                             0                             0                             0
  0.2118356013569296092403E-01 -0.1500082858934205787271E+00  0.8715064064818685007907E+00  0.1275989254710248495261E-02  0.9997027456190182848061E+00  0.2434732538119873876403E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           541                             0                             0                             0                             0                             0                             0
  0.2045345152100954198327E-15 -0.1500082858934205787271E+00  0.8720611175261379077739E+00  0.1232011248126845051401E-16  0.9997027456190183958284E+00  0.2438073833574570803417E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           542                             0                             0                             0                             0                             0                             0
 -0.2118356013569291235177E-01 -0.1500082858934205787271E+00  0.8715064064818685007907E+00 -0.1275989254710245459495E-02  0.9997027456190182848061E+00  0.2434732538119873876403E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           543                             0                             0                             0                             0                             0                             0
 -0.4230905760550512234586E-01 -0.1500082858934205787271E+00  0.8698437937734750935448E+00 -0.2548481111566257110990E-02  0.9997027456190183958284E+00  0.2424717810014374516636E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           544                             0                             0                             0                             0                             0                             0
 -0.6331858888928737494339E-01 -0.1500082858934205787271E+00  0.8670778365068245729930E+00 -0.3813987758838227083713E-02  0.9997027456190185068508E+00  0.2408057098931693992827E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           545                             0                             0                             0                             0                             0                             0
 -0.8415456832214503191114E-01 -0.1500082858934205787271E+00  0.8632161159785256554500E+00 -0.5069040530770248416392E-02  0.9997027456190185068508E+00  0.2384796070722838140510E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           546                             0                             0                             0                             0                             0                             0
 -0.1047598859327440318223E+00 -0.1500082858934205787271E+00  0.8582692168961214562728E+00 -0.6310199414952116780952E-02  0.9997027456190185068508E+00  0.2354998482249274008304E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           547                             0                             0                             0                             0                             0                             0
 -0.1250780639777719360772E+00 -0.1500082858934205787271E+00  0.8522506983661419788234E+00 -0.7534062481154194836075E-02  0.9997027456190185068508E+00  0.2318746006629801570398E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           548                             0                             0                             0                             0                             0                             0
 -0.1450534117435062220203E+00 -0.1500082858934205787271E+00  0.8451770567295358027593E+00 -0.8737275205781680834094E-02  0.9997027456190183958284E+00  0.2276138009380215820876E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           549                             0                             0                             0                             0                             0                             0
 -0.1646311781901907689285E+00 -0.1500082858934205787271E+00  0.8370676803463461546073E+00 -0.9916539666390682475350E-02  0.9997027456190183958284E+00  0.2227291276059331637249E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           550                             0                             0                             0                             0                             0                             0
 -0.1837577020208287226222E+00 -0.1500082858934205787271E+00  0.8279447964535635584582E+00 -0.1106862358106431784566E-01  0.9997027456190183958284E+00  0.2172339692167887803542E-01
