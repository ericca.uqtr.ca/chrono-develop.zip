                          2570                             1                             2                          2570                          2571                          2690                          2691
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2571                             1                             2                          2571                          2572                          2691                          2692
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2572                             1                             2                          2572                          2573                          2692                          2693
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2573                             1                             2                          2573                          2574                          2693                          2694
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2574                             1                             2                          2574                          2575                          2694                          2695
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2575                             1                             2                          2575                          2576                          2695                          2696
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2576                             1                             2                          2576                          2577                          2696                          2697
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2577                             1                             2                          2577                          2578                          2697                          2698
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2578                             1                             2                          2578                          2579                          2698                          2699
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2579                             1                             2                          2579                          2580                          2699                          2700
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2580                             1                             2                          2580                          2581                          2700                          2701
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2581                             1                             2                          2581                          2582                          2701                          2702
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2582                             1                             2                          2582                          2583                          2702                          2703
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2583                             1                             2                          2583                          2584                          2703                          2704
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2584                             1                             2                          2584                          2585                          2704                          2705
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2585                             1                             2                          2585                          2586                          2705                          2706
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2586                             1                             2                          2586                          2587                          2706                          2707
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2587                             1                             2                          2587                          2588                          2707                          2708
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2588                             1                             2                          2588                          2589                          2708                          2709
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2589                             1                             2                          2589                          2590                          2709                          2710
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2590                             1                             2                          2590                          2591                          2710                          2711
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2591                             1                             2                          2591                          2592                          2711                          2712
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2592                             1                             2                          2592                          2593                          2712                          2713
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2593                             1                             2                          2593                          2594                          2713                          2714
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2594                             1                             2                          2594                          2595                          2714                          2715
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2595                             1                             2                          2595                          2596                          2715                          2716
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2596                             1                             2                          2596                          2597                          2716                          2717
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2597                             1                             2                          2597                          2598                          2717                          2718
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2598                             1                             2                          2598                          2599                          2718                          2719
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2599                             1                             2                          2599                          2600                          2719                          2720
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2600                             1                             2                          2600                          2601                          2720                          2721
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2601                             1                             2                          2601                          2602                          2721                          2722
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2602                             1                             2                          2602                          2603                          2722                          2723
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2603                             1                             2                          2603                          2604                          2723                          2724
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2604                             1                             2                          2604                          2605                          2724                          2725
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2605                             1                             2                          2605                          2606                          2725                          2726
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2606                             1                             2                          2606                          2607                          2726                          2727
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2607                             1                             2                          2607                          2608                          2727                          2728
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2608                             1                             2                          2608                          2609                          2728                          2729
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2609                             1                             2                          2609                          2610                          2729                          2730
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2610                             1                             2                          2610                          2611                          2730                          2731
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2611                             1                             2                          2611                          2612                          2731                          2732
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2612                             1                             2                          2612                          2613                          2732                          2733
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2613                             1                             2                          2613                          2614                          2733                          2734
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2614                             1                             2                          2614                          2615                          2734                          2735
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2615                             1                             2                          2615                          2616                          2735                          2736
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2616                             1                             2                          2616                          2617                          2736                          2737
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2617                             1                             2                          2617                          2618                          2737                          2738
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2618                             1                             2                          2618                          2619                          2738                          2739
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2619                             1                             2                          2619                          2620                          2739                          2740
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2620                             1                             2                          2620                          2621                          2740                          2741
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2621                             1                             2                          2621                          2622                          2741                          2742
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2622                             1                             2                          2622                          2623                          2742                          2743
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2623                             1                             2                          2623                          2624                          2743                          2744
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2624                             1                             2                          2624                          2625                          2744                          2745
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2625                             1                             2                          2625                          2626                          2745                          2746
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2626                             1                             2                          2626                          2627                          2746                          2747
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2627                             1                             2                          2627                          2628                          2747                          2748
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2628                             1                             2                          2628                          2629                          2748                          2749
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2629                             1                             2                          2629                          2630                          2749                          2750
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2630                             1                             2                          2630                          2631                          2750                          2751
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2631                             1                             2                          2631                          2632                          2751                          2752
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2632                             1                             2                          2632                          2633                          2752                          2753
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2633                             1                             2                          2633                          2634                          2753                          2754
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2634                             1                             2                          2634                          2635                          2754                          2755
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2635                             1                             2                          2635                          2636                          2755                          2756
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2636                             1                             2                          2636                          2637                          2756                          2757
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2637                             1                             2                          2637                          2638                          2757                          2758
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2638                             1                             2                          2638                          2639                          2758                          2759
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2639                             1                             2                          2639                          2640                          2759                          2760
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2640                             1                             2                          2640                          2521                          2760                          2641
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2641                             1                             1                          2641                          2642                          2761                          2762
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2642                             1                             1                          2642                          2643                          2762                          2763
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2643                             1                             1                          2643                          2644                          2763                          2764
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2644                             1                             1                          2644                          2645                          2764                          2765
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2645                             1                             1                          2645                          2646                          2765                          2766
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2646                             1                             1                          2646                          2647                          2766                          2767
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2647                             1                             1                          2647                          2648                          2767                          2768
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2648                             1                             1                          2648                          2649                          2768                          2769
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2649                             1                             1                          2649                          2650                          2769                          2770
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2650                             1                             1                          2650                          2651                          2770                          2771
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2651                             1                             1                          2651                          2652                          2771                          2772
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2652                             1                             1                          2652                          2653                          2772                          2773
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2653                             1                             1                          2653                          2654                          2773                          2774
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2654                             1                             1                          2654                          2655                          2774                          2775
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2655                             1                             1                          2655                          2656                          2775                          2776
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2656                             1                             1                          2656                          2657                          2776                          2777
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2657                             1                             1                          2657                          2658                          2777                          2778
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2658                             1                             1                          2658                          2659                          2778                          2779
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2659                             1                             1                          2659                          2660                          2779                          2780
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2660                             1                             1                          2660                          2661                          2780                          2781
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2661                             1                             1                          2661                          2662                          2781                          2782
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2662                             1                             1                          2662                          2663                          2782                          2783
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2663                             1                             1                          2663                          2664                          2783                          2784
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2664                             1                             1                          2664                          2665                          2784                          2785
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2665                             1                             1                          2665                          2666                          2785                          2786
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2666                             1                             1                          2666                          2667                          2786                          2787
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2667                             1                             1                          2667                          2668                          2787                          2788
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2668                             1                             1                          2668                          2669                          2788                          2789
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2669                             1                             1                          2669                          2670                          2789                          2790
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2670                             1                             1                          2670                          2671                          2790                          2791
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2671                             1                             1                          2671                          2672                          2791                          2792
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2672                             1                             1                          2672                          2673                          2792                          2793
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2673                             1                             1                          2673                          2674                          2793                          2794
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2674                             1                             1                          2674                          2675                          2794                          2795
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2675                             1                             1                          2675                          2676                          2795                          2796
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2676                             1                             1                          2676                          2677                          2796                          2797
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2677                             1                             1                          2677                          2678                          2797                          2798
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2678                             1                             1                          2678                          2679                          2798                          2799
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2679                             1                             1                          2679                          2680                          2799                          2800
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2680                             1                             1                          2680                          2681                          2800                          2801
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2681                             1                             1                          2681                          2682                          2801                          2802
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2682                             1                             1                          2682                          2683                          2802                          2803
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2683                             1                             1                          2683                          2684                          2803                          2804
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2684                             1                             1                          2684                          2685                          2804                          2805
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2685                             1                             1                          2685                          2686                          2805                          2806
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2686                             1                             1                          2686                          2687                          2806                          2807
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2687                             1                             1                          2687                          2688                          2807                          2808
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2688                             1                             1                          2688                          2689                          2808                          2809
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2689                             1                             1                          2689                          2690                          2809                          2810
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2690                             1                             1                          2690                          2691                          2810                          2811
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2691                             1                             1                          2691                          2692                          2811                          2812
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2692                             1                             1                          2692                          2693                          2812                          2813
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2693                             1                             1                          2693                          2694                          2813                          2814
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2694                             1                             1                          2694                          2695                          2814                          2815
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2695                             1                             1                          2695                          2696                          2815                          2816
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2696                             1                             1                          2696                          2697                          2816                          2817
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2697                             1                             1                          2697                          2698                          2817                          2818
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2698                             1                             1                          2698                          2699                          2818                          2819
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2699                             1                             1                          2699                          2700                          2819                          2820
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2700                             1                             1                          2700                          2701                          2820                          2821
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2701                             1                             1                          2701                          2702                          2821                          2822
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2702                             1                             1                          2702                          2703                          2822                          2823
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2703                             1                             1                          2703                          2704                          2823                          2824
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2704                             1                             1                          2704                          2705                          2824                          2825
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2705                             1                             1                          2705                          2706                          2825                          2826
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2706                             1                             1                          2706                          2707                          2826                          2827
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2707                             1                             1                          2707                          2708                          2827                          2828
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2708                             1                             1                          2708                          2709                          2828                          2829
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2709                             1                             1                          2709                          2710                          2829                          2830
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2710                             1                             1                          2710                          2711                          2830                          2831
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2711                             1                             1                          2711                          2712                          2831                          2832
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2712                             1                             1                          2712                          2713                          2832                          2833
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2713                             1                             1                          2713                          2714                          2833                          2834
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2714                             1                             1                          2714                          2715                          2834                          2835
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2715                             1                             1                          2715                          2716                          2835                          2836
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2716                             1                             1                          2716                          2717                          2836                          2837
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2717                             1                             1                          2717                          2718                          2837                          2838
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2718                             1                             1                          2718                          2719                          2838                          2839
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2719                             1                             1                          2719                          2720                          2839                          2840
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2720                             1                             1                          2720                          2721                          2840                          2841
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2721                             1                             1                          2721                          2722                          2841                          2842
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2722                             1                             1                          2722                          2723                          2842                          2843
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2723                             1                             1                          2723                          2724                          2843                          2844
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2724                             1                             1                          2724                          2725                          2844                          2845
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2725                             1                             1                          2725                          2726                          2845                          2846
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2726                             1                             1                          2726                          2727                          2846                          2847
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2727                             1                             1                          2727                          2728                          2847                          2848
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2728                             1                             1                          2728                          2729                          2848                          2849
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2729                             1                             1                          2729                          2730                          2849                          2850
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2730                             1                             1                          2730                          2731                          2850                          2851
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2731                             1                             1                          2731                          2732                          2851                          2852
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2732                             1                             1                          2732                          2733                          2852                          2853
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2733                             1                             1                          2733                          2734                          2853                          2854
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2734                             1                             1                          2734                          2735                          2854                          2855
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2735                             1                             1                          2735                          2736                          2855                          2856
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2736                             1                             1                          2736                          2737                          2856                          2857
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2737                             1                             1                          2737                          2738                          2857                          2858
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2738                             1                             1                          2738                          2739                          2858                          2859
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2739                             1                             1                          2739                          2740                          2859                          2860
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2740                             1                             1                          2740                          2741                          2860                          2861
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2741                             1                             1                          2741                          2742                          2861                          2862
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2742                             1                             1                          2742                          2743                          2862                          2863
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2743                             1                             1                          2743                          2744                          2863                          2864
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2744                             1                             1                          2744                          2745                          2864                          2865
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2745                             1                             1                          2745                          2746                          2865                          2866
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2746                             1                             1                          2746                          2747                          2866                          2867
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2747                             1                             1                          2747                          2748                          2867                          2868
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2748                             1                             1                          2748                          2749                          2868                          2869
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2749                             1                             1                          2749                          2750                          2869                          2870
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2750                             1                             1                          2750                          2751                          2870                          2871
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2751                             1                             1                          2751                          2752                          2871                          2872
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2752                             1                             1                          2752                          2753                          2872                          2873
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2753                             1                             1                          2753                          2754                          2873                          2874
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2754                             1                             1                          2754                          2755                          2874                          2875
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2755                             1                             1                          2755                          2756                          2875                          2876
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2756                             1                             1                          2756                          2757                          2876                          2877
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2757                             1                             1                          2757                          2758                          2877                          2878
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2758                             1                             1                          2758                          2759                          2878                          2879
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2759                             1                             1                          2759                          2760                          2879                          2880
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2760                             1                             1                          2760                          2641                          2880                          2761
  0.1672069324273456336627E-01  0.3634527111146472477810E-01
                          2761                             1                             1                          2761                          2762                          2881                          2882
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2762                             1                             1                          2762                          2763                          2882                          2883
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2763                             1                             1                          2763                          2764                          2883                          2884
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2764                             1                             1                          2764                          2765                          2884                          2885
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2765                             1                             1                          2765                          2766                          2885                          2886
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2766                             1                             1                          2766                          2767                          2886                          2887
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2767                             1                             1                          2767                          2768                          2887                          2888
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2768                             1                             1                          2768                          2769                          2888                          2889
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2769                             1                             1                          2769                          2770                          2889                          2890
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2770                             1                             1                          2770                          2771                          2890                          2891
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2771                             1                             1                          2771                          2772                          2891                          2892
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2772                             1                             1                          2772                          2773                          2892                          2893
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2773                             1                             1                          2773                          2774                          2893                          2894
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2774                             1                             1                          2774                          2775                          2894                          2895
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2775                             1                             1                          2775                          2776                          2895                          2896
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2776                             1                             1                          2776                          2777                          2896                          2897
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2777                             1                             1                          2777                          2778                          2897                          2898
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2778                             1                             1                          2778                          2779                          2898                          2899
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2779                             1                             1                          2779                          2780                          2899                          2900
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2780                             1                             1                          2780                          2781                          2900                          2901
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2781                             1                             1                          2781                          2782                          2901                          2902
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2782                             1                             1                          2782                          2783                          2902                          2903
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2783                             1                             1                          2783                          2784                          2903                          2904
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2784                             1                             1                          2784                          2785                          2904                          2905
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2785                             1                             1                          2785                          2786                          2905                          2906
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2786                             1                             1                          2786                          2787                          2906                          2907
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2787                             1                             1                          2787                          2788                          2907                          2908
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2788                             1                             1                          2788                          2789                          2908                          2909
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2789                             1                             1                          2789                          2790                          2909                          2910
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2790                             1                             1                          2790                          2791                          2910                          2911
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2791                             1                             1                          2791                          2792                          2911                          2912
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2792                             1                             1                          2792                          2793                          2912                          2913
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2793                             1                             1                          2793                          2794                          2913                          2914
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2794                             1                             1                          2794                          2795                          2914                          2915
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2795                             1                             1                          2795                          2796                          2915                          2916
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2796                             1                             1                          2796                          2797                          2916                          2917
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2797                             1                             1                          2797                          2798                          2917                          2918
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2798                             1                             1                          2798                          2799                          2918                          2919
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2799                             1                             1                          2799                          2800                          2919                          2920
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2800                             1                             1                          2800                          2801                          2920                          2921
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2801                             1                             1                          2801                          2802                          2921                          2922
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2802                             1                             1                          2802                          2803                          2922                          2923
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2803                             1                             1                          2803                          2804                          2923                          2924
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2804                             1                             1                          2804                          2805                          2924                          2925
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2805                             1                             1                          2805                          2806                          2925                          2926
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2806                             1                             1                          2806                          2807                          2926                          2927
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2807                             1                             1                          2807                          2808                          2927                          2928
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2808                             1                             1                          2808                          2809                          2928                          2929
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2809                             1                             1                          2809                          2810                          2929                          2930
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2810                             1                             1                          2810                          2811                          2930                          2931
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2811                             1                             1                          2811                          2812                          2931                          2932
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2812                             1                             1                          2812                          2813                          2932                          2933
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2813                             1                             1                          2813                          2814                          2933                          2934
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2814                             1                             1                          2814                          2815                          2934                          2935
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2815                             1                             1                          2815                          2816                          2935                          2936
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2816                             1                             1                          2816                          2817                          2936                          2937
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2817                             1                             1                          2817                          2818                          2937                          2938
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2818                             1                             1                          2818                          2819                          2938                          2939
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2819                             1                             1                          2819                          2820                          2939                          2940
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2820                             1                             1                          2820                          2821                          2940                          2941
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2821                             1                             1                          2821                          2822                          2941                          2942
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2822                             1                             1                          2822                          2823                          2942                          2943
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2823                             1                             1                          2823                          2824                          2943                          2944
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2824                             1                             1                          2824                          2825                          2944                          2945
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2825                             1                             1                          2825                          2826                          2945                          2946
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2826                             1                             1                          2826                          2827                          2946                          2947
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2827                             1                             1                          2827                          2828                          2947                          2948
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2828                             1                             1                          2828                          2829                          2948                          2949
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2829                             1                             1                          2829                          2830                          2949                          2950
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2830                             1                             1                          2830                          2831                          2950                          2951
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2831                             1                             1                          2831                          2832                          2951                          2952
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2832                             1                             1                          2832                          2833                          2952                          2953
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2833                             1                             1                          2833                          2834                          2953                          2954
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2834                             1                             1                          2834                          2835                          2954                          2955
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2835                             1                             1                          2835                          2836                          2955                          2956
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2836                             1                             1                          2836                          2837                          2956                          2957
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2837                             1                             1                          2837                          2838                          2957                          2958
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2838                             1                             1                          2838                          2839                          2958                          2959
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2839                             1                             1                          2839                          2840                          2959                          2960
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2840                             1                             1                          2840                          2841                          2960                          2961
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2841                             1                             1                          2841                          2842                          2961                          2962
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2842                             1                             1                          2842                          2843                          2962                          2963
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2843                             1                             1                          2843                          2844                          2963                          2964
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2844                             1                             1                          2844                          2845                          2964                          2965
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2845                             1                             1                          2845                          2846                          2965                          2966
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2846                             1                             1                          2846                          2847                          2966                          2967
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2847                             1                             1                          2847                          2848                          2967                          2968
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2848                             1                             1                          2848                          2849                          2968                          2969
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2849                             1                             1                          2849                          2850                          2969                          2970
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2850                             1                             1                          2850                          2851                          2970                          2971
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2851                             1                             1                          2851                          2852                          2971                          2972
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2852                             1                             1                          2852                          2853                          2972                          2973
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2853                             1                             1                          2853                          2854                          2973                          2974
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2854                             1                             1                          2854                          2855                          2974                          2975
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2855                             1                             1                          2855                          2856                          2975                          2976
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2856                             1                             1                          2856                          2857                          2976                          2977
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2857                             1                             1                          2857                          2858                          2977                          2978
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2858                             1                             1                          2858                          2859                          2978                          2979
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2859                             1                             1                          2859                          2860                          2979                          2980
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2860                             1                             1                          2860                          2861                          2980                          2981
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2861                             1                             1                          2861                          2862                          2981                          2982
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2862                             1                             1                          2862                          2863                          2982                          2983
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2863                             1                             1                          2863                          2864                          2983                          2984
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2864                             1                             1                          2864                          2865                          2984                          2985
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2865                             1                             1                          2865                          2866                          2985                          2986
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2866                             1                             1                          2866                          2867                          2986                          2987
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2867                             1                             1                          2867                          2868                          2987                          2988
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2868                             1                             1                          2868                          2869                          2988                          2989
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2869                             1                             1                          2869                          2870                          2989                          2990
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2870                             1                             1                          2870                          2871                          2990                          2991
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2871                             1                             1                          2871                          2872                          2991                          2992
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2872                             1                             1                          2872                          2873                          2992                          2993
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2873                             1                             1                          2873                          2874                          2993                          2994
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2874                             1                             1                          2874                          2875                          2994                          2995
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2875                             1                             1                          2875                          2876                          2995                          2996
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2876                             1                             1                          2876                          2877                          2996                          2997
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2877                             1                             1                          2877                          2878                          2997                          2998
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2878                             1                             1                          2878                          2879                          2998                          2999
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2879                             1                             1                          2879                          2880                          2999                          3000
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
                          2880                             1                             1                          2880                          2761                          3000                          2881
  0.1493900110565799313478E-01  0.3488311435742893346079E-01
 NODES [#ofNode, Constrain/ Coordinate / Velocity]
                             1                             0                             0                             0                             0                             0                             0
  0.1642863681056174140932E-16 -0.1150000000000000049960E+00  0.1990000000000000102141E+00  0.3548016624496210321019E-17  0.9983198634690081396670E+00 -0.5794350872376390765295E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                             2                             0                             0                             0                             0                             0                             0
  0.1404173705998186527655E-01 -0.1150000000000000049960E+00  0.1993676958253478570526E+00  0.3032528937129549788387E-02  0.9983198634690080286447E+00 -0.5786409915885994126317E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                             3                             0                             0                             0                             0                             0                             0
  0.2804498669471142124898E-01 -0.1150000000000000049960E+00  0.2004697754726922909185E+00  0.6056745923230913257462E-02  0.9983198634690081396670E+00 -0.5762608812024575671851E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                             4                             0                             0                             0                             0                             0                             0
  0.4197136697029395235869E-01 -0.1150000000000000049960E+00  0.2023032182183245319962E+00  0.9064361789755960227555E-02  0.9983198634690081396670E+00 -0.5723012797963426129266E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                             5                             0                             0                             0                             0                             0                             0
  0.5578270664640485460017E-01 -0.1150000000000000049960E+00  0.2048629987231199711673E+00  0.1204713287067134958042E-01  0.9983198634690080286447E+00 -0.5667730403624800239459E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                             6                             0                             0                             0                             0                             0                             0
  0.6944114980100631051574E-01 -0.1150000000000000049960E+00  0.2081421008066429712002E+00  0.1499688359777415561092E-01  0.9983198634690081396670E+00 -0.5596913154208948970592E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                             7                             0                             0                             0                             0                             0                             0
  0.8290925959079839535626E-01 -0.1150000000000000049960E+00  0.2121315366780103239819E+00  0.1790552890935607002754E-01  0.9983198634690081396670E+00 -0.5510755154874073802329E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                             8                             0                             0                             0                             0                             0                             0
  0.9615012086300409044348E-01 -0.1150000000000000049960E+00  0.2168203715708008072482E+00  0.2076509641079549509102E-01  0.9983198634690081396670E+00 -0.5409492558707584136668E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                             9                             0                             0                             0                             0                             0                             0
  0.1091274413372371882014E+00 -0.1150000000000000049960E+00  0.2221957537144901850823E+00  0.2356774822633707702768E-01  0.9983198634690081396670E+00 -0.5293402919446893450939E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            10                             0                             0                             0                             0                             0                             0
  0.1218056510801203973227E+00 -0.1150000000000000049960E+00  0.2282429495602609215155E+00  0.2630580248216436711761E-01  0.9983198634690080286447E+00 -0.5162804430723924586921E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            11                             0                             0                             0                             0                             0                             0
  0.1341499999999999637179E+00 -0.1150000000000000049960E+00  0.2349453841646350904515E+00  0.2897175436188194688758E-01  0.9983198634690081396670E+00 -0.5018055053918478447539E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            12                             0                             0                             0                             0                             0                             0
  0.1461266530945317665413E+00 -0.1150000000000000049960E+00  0.2422846866202427451586E+00  0.3155829667669558108445E-01  0.9983198634690081396670E+00 -0.4859551537010971256070E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            13                             0                             0                             0                             0                             0                             0
  0.1577027831900705279189E+00 -0.1150000000000000049960E+00  0.2502407404092016340869E+00  0.3405833989390868316027E-01  0.9983198634690082506893E+00 -0.4687728327123802385401E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            14                             0                             0                             0                             0                             0                             0
  0.1688466609186713984769E+00 -0.1150000000000000049960E+00  0.2587917385410947179736E+00  0.3646503156883876967109E-01  0.9983198634690080286447E+00 -0.4503056379731987940440E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            15                             0                             0                             0                             0                             0                             0
  0.1795277416860816543931E+00 -0.1150000000000000049960E+00  0.2679142433244151577654E+00  0.3877177512689193583650E-01  0.9983198634690080286447E+00 -0.4306041867806939538177E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            16                             0                             0                             0                             0                             0                             0
  0.1897167493923506698117E+00 -0.1150000000000000049960E+00  0.2775832506076493233493E+00  0.4097224794431533062555E-01  0.9983198634690082506893E+00 -0.4097224794431533756445E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            17                             0                             0                             0                             0                             0                             0
  0.1993857566755848631512E+00 -0.1150000000000000049960E+00  0.2877722583139183387679E+00  0.4306041867806940232066E-01  0.9983198634690080286447E+00 -0.3877177512689193583650E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            18                             0                             0                             0                             0                             0                             0
  0.2085082614589052751874E+00 -0.1150000000000000049960E+00  0.2984533390813286501952E+00  0.4503056379731988634330E-01  0.9983198634690080286447E+00 -0.3646503156883876967109E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            19                             0                             0                             0                             0                             0                             0
  0.2170592595907983868297E+00 -0.1150000000000000049960E+00  0.3095972168099294652421E+00  0.4687728327123802385401E-01  0.9983198634690082506893E+00 -0.3405833989390868316027E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            20                             0                             0                             0                             0                             0                             0
  0.2250153133797572480024E+00 -0.1150000000000000049960E+00  0.3211733469054682266197E+00  0.4859551537010971256070E-01  0.9983198634690081396670E+00 -0.3155829667669558108445E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            21                             0                             0                             0                             0                             0                             0
  0.2323546158353648471984E+00 -0.1150000000000000049960E+00  0.3331500000000000016875E+00  0.5018055053918477753649E-01  0.9983198634690080286447E+00 -0.2897175436188195382647E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            22                             0                             0                             0                             0                             0                             0
  0.2390570504397390994011E+00 -0.1150000000000000049960E+00  0.3454943489198796235939E+00  0.5162804430723925280811E-01  0.9983198634690082506893E+00 -0.2630580248216436364816E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            23                             0                             0                             0                             0                             0                             0
  0.2451042462855098080787E+00 -0.1150000000000000049960E+00  0.3581725586627627633263E+00  0.5293402919446893450939E-01  0.9983198634690082506893E+00 -0.2356774822633708396658E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            24                             0                             0                             0                             0                             0                             0
  0.2504796284291991859128E+00 -0.1150000000000000049960E+00  0.3711498791369959304731E+00  0.5409492558707584136668E-01  0.9983198634690081396670E+00 -0.2076509641079549162157E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            25                             0                             0                             0                             0                             0                             0
  0.2551684633219896691791E+00 -0.1150000000000000049960E+00  0.3843907404092016255603E+00  0.5510755154874073802329E-01  0.9983198634690080286447E+00 -0.1790552890935606655809E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            26                             0                             0                             0                             0                             0                             0
  0.2591578991933570219608E+00 -0.1150000000000000049960E+00  0.3978588501989936965231E+00  0.5596913154208948970592E-01  0.9983198634690081396670E+00 -0.1499688359777415214147E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            27                             0                             0                             0                             0                             0                             0
  0.2624370012768800219938E+00 -0.1150000000000000049960E+00  0.4115172933535952148887E+00  0.5667730403624800239459E-01  0.9983198634690081396670E+00 -0.1204713287067133396790E-01
