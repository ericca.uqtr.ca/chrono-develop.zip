  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2120                             0                             0                             0                             0                             0                             0
 -0.3875780938894168303754E+00  0.1043862266863211235579E+00  0.7189961571288048247652E+00  0.7770917259831423562488E+00 -0.3761084501259890355840E+00 -0.5046492674644117437666E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2121                             0                             0                             0                             0                             0                             0
 -0.4002196906478630022974E+00  0.1043862266863211235579E+00  0.6983669461305326287004E+00  0.8024380507602251189070E+00 -0.3761084501259890355840E+00 -0.4632878246144149780861E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2122                             0                             0                             0                             0                             0                             0
 -0.4117643130531731809896E+00  0.1043862266863211235579E+00  0.6771043966941827640937E+00  0.8255849486169595241591E+00 -0.3761084501259890355840E+00 -0.4206565420398912791278E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2123                             0                             0                             0                             0                             0                             0
 -0.4221803180977909408789E+00  0.1043862266863211235579E+00  0.6552667879898194103205E+00  0.8464689755152406958061E+00 -0.3761084501259890910951E+00 -0.3768722691231147781110E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2124                             0                             0                             0                             0                             0                             0
 -0.4314391562358970144686E+00  0.1043862266863211235579E+00  0.6329139753849863936352E+00  0.8650328897889723034353E+00 -0.3761084501259890355840E+00 -0.3320550155127405256295E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2125                             0                             0                             0                             0                             0                             0
 -0.4395154496357283058217E+00  0.1043862266863211235579E+00  0.6101072263853101196318E+00  0.8812258090394905485354E+00 -0.3761084501259890355840E+00 -0.2863276221857084524736E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2126                             0                             0                             0                             0                             0                             0
 -0.4463870617384524952520E+00  0.1043862266863211235579E+00  0.5869090527045199845446E+00  0.8950033496006868372064E+00 -0.3761084501259890355840E+00 -0.2398154247486536383427E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2127                             0                             0                             0                             0                             0                             0
 -0.4520351579329357494252E+00  0.1043862266863211235579E+00  0.5633830389241903935371E+00  0.9063277481915475997098E+00 -0.3761084501259890355840E+00 -0.1926459099017293619127E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2128                             0                             0                             0                             0                             0                             0
 -0.4564442571801033965428E+00  0.1043862266863211235579E+00  0.5395936682128193995212E+00  0.9151679654226847482335E+00 -0.3761084501259890355840E+00 -0.1449483660064166123949E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2129                             0                             0                             0                             0                             0                             0
 -0.4596022744453917563412E+00  0.1043862266863211235579E+00  0.5156061455819487271413E+00  0.9214997708731436087959E+00 -0.3761084501259890355840E+00 -0.9685352871511850036956E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2130                             0                             0                             0                             0                             0                             0
 -0.4615005538229877135592E+00  0.1043862266863211235579E+00  0.4914862191637561772417E+00  0.9253058095043030784055E+00 -0.3761084501259890355840E+00 -0.4849322263381684872119E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2131                             0                             0                             0                             0                             0                             0
 -0.4621338922610649935230E+00  0.1043862266863211235579E+00  0.4673000000000000486722E+00  0.9265756492288292900383E+00 -0.3761084501259890355840E+00 -0.1134727902995966400235E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2132                             0                             0                             0                             0                             0                             0
 -0.4615005538229876580480E+00  0.1043862266863211235579E+00  0.4431137808362434760134E+00  0.9253058095043029673832E+00 -0.3761084501259890355840E+00  0.4849322263381743852717E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2133                             0                             0                             0                             0                             0                             0
 -0.4596022744453918118523E+00  0.1043862266863211235579E+00  0.4189938544180517032700E+00  0.9214997708731437198182E+00 -0.3761084501259890910951E+00  0.9685352871511745953548E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2134                             0                             0                             0                             0                             0                             0
 -0.4564442571801034520540E+00  0.1043862266863211235579E+00  0.3950063317871806978232E+00  0.9151679654226848592558E+00 -0.3761084501259890355840E+00  0.1449483660064163903503E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2135                             0                             0                             0                             0                             0                             0
 -0.4520351579329357494252E+00  0.1043862266863211235579E+00  0.3712169610758096482961E+00  0.9063277481915475997098E+00 -0.3761084501259890355840E+00  0.1926459099017291398681E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2136                             0                             0                             0                             0                             0                             0
 -0.4463870617384524397409E+00  0.1043862266863211235579E+00  0.3476909472954797797328E+00  0.8950033496006867261841E+00 -0.3761084501259890910951E+00  0.2398154247486542212098E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2137                             0                             0                             0                             0                             0                             0
 -0.4395154496357283613328E+00  0.1043862266863211235579E+00  0.3244927736146899777125E+00  0.8812258090394906595577E+00 -0.3761084501259890355840E+00  0.2863276221857082859401E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2138                             0                             0                             0                             0                             0                             0
 -0.4314391562358970144686E+00  0.1043862266863211235579E+00  0.3016860246150137037091E+00  0.8650328897889723034353E+00 -0.3761084501259889800728E+00  0.3320550155127403035848E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2139                             0                             0                             0                             0                             0                             0
 -0.4221803180977911074123E+00  0.1043862266863211235579E+00  0.2793332120101810756019E+00  0.8464689755152410288730E+00 -0.3761084501259890355840E+00  0.3768722691231138344214E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2140                             0                             0                             0                             0                             0                             0
 -0.4117643130531732365007E+00  0.1043862266863211235579E+00  0.2574956033058172777395E+00  0.8255849486169595241591E+00 -0.3761084501259890355840E+00  0.4206565420398911125943E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2141                             0                             0                             0                             0                             0                             0
 -0.4002196906478630578086E+00  0.1043862266863211235579E+00  0.2362330538694674408884E+00  0.8024380507602252299293E+00 -0.3761084501259890355840E+00  0.4632878246144147560415E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2142                             0                             0                             0                             0                             0                             0
 -0.3875780938894168858866E+00  0.1043862266863211235579E+00  0.2156038428711952170680E+00  0.7770917259831424672711E+00 -0.3761084501259890355840E+00  0.5046492674644115217220E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2143                             0                             0                             0                             0                             0                             0
 -0.3738741725158426509878E+00  0.1043862266863211235579E+00  0.1956645135444273764236E+00  0.7496154468001231530039E+00 -0.3761084501259890355840E+00  0.5446275017500293857964E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2144                             0                             0                             0                             0                             0                             0
 -0.3591454880230777746419E+00  0.1043862266863211235579E+00  0.1764697182048833856705E+00  0.7200845237825559408407E+00 -0.3761084501259890355840E+00  0.5831129499099433344256E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2145                             0                             0                             0                             0                             0                             0
 -0.3434324107115379054456E+00  0.1043862266863211235579E+00  0.1580720684523741481620E+00  0.6885798991377612976450E+00 -0.3761084501259890355840E+00  0.6200001260058395358143E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2146                             0                             0                             0                             0                             0                             0
 -0.3267780090339325038684E+00  0.1043862266863211235579E+00  0.1405219909660676003149E+00  0.6551879248520331433525E+00 -0.3761084501259890910951E+00  0.6551879248520329213079E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2147                             0                             0                             0                             0                             0                             0
 -0.3092279315476256229545E+00  0.1043862266863211235579E+00  0.1238675892884618656709E+00  0.6200001260058392027474E+00 -0.3761084501259890355840E+00  0.6885798991377617417342E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2148                             0                             0                             0                             0                             0                             0
 -0.2908302817951170515798E+00  0.1043862266863211235579E+00  0.1081545119769226070972E+00  0.5831129499099442226040E+00 -0.3761084501259890355840E+00  0.7200845237825552747069E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2149                             0                             0                             0                             0                             0                             0
 -0.2716354864555727277597E+00  0.1043862266863211235579E+00  0.9342582748415745319548E-01  0.5446275017500296078410E+00 -0.3761084501259890355840E+00  0.7496154468001229309593E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2150                             0                             0                             0                             0                             0                             0
 -0.2516961571288052201822E+00  0.1043862266863211235579E+00  0.7972190611058338483019E-01  0.5046492674644124099004E+00 -0.3761084501259890910951E+00  0.7770917259831419121596E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2151                             0                             0                             0                             0                             0                             0
 -0.2310669461305323302280E+00  0.1043862266863211235579E+00  0.6708030935213682433016E-01  0.4632878246144143119523E+00 -0.3761084501259890355840E+00  0.8024380507602254519739E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2152                             0                             0                             0                             0                             0                             0
 -0.2098043966941828264439E+00  0.1043862266863211235579E+00  0.5553568694682681217145E-01  0.4206565420398913346389E+00 -0.3761084501259890910951E+00  0.8255849486169595241591E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2153                             0                             0                             0                             0                             0                             0
 -0.1879667879898190563370E+00  0.1043862266863211235579E+00  0.4511968190220894125986E-01  0.3768722691231141119772E+00 -0.3761084501259890355840E+00  0.8464689755152409178507E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2154                             0                             0                             0                             0                             0                             0
 -0.1656139753849867612967E+00  0.1043862266863211235579E+00  0.3586084376410308971472E-01  0.3320550155127413582967E+00 -0.3761084501259890355840E+00  0.8650328897889719703684E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2155                             0                             0                             0                             0                             0                             0
 -0.1428072263853101542264E+00  0.1043862266863211235579E+00  0.2778455036427168733937E-01  0.2863276221857085079847E+00 -0.3761084501259890355840E+00  0.8812258090394905485354E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2156                             0                             0                             0                             0                             0                             0
 -0.1196090527045199913836E+00  0.1043862266863211235579E+00  0.2091293826154749790902E-01  0.2398154247486536938538E+00 -0.3761084501259890355840E+00  0.8950033496006868372064E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2157                             0                             0                             0                             0                             0                             0
 -0.9608303892419005343140E-01  0.1043862266863211235579E+00  0.1526484206706424373579E-01  0.1926459099017286125122E+00 -0.3761084501259890355840E+00  0.9063277481915477107322E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2158                             0                             0                             0                             0                             0                             0
 -0.7229366821281946187128E-01  0.1043862266863211235579E+00  0.1085574281989659661818E-01  0.1449483660064166679060E+00 -0.3761084501259890355840E+00  0.9151679654226847482335E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2159                             0                             0                             0                             0                             0                             0
 -0.4830614558194840785221E-01  0.1043862266863211235579E+00  0.7697725554608181308680E-02  0.9685352871511775096902E-01 -0.3761084501259890910951E+00  0.9214997708731437198182E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2160                             0                             0                             0                             0                             0                             0
 -0.2418621916375663510879E-01  0.1043862266863211235579E+00  0.5799446177012335112977E-02  0.4849322263381772302182E-01 -0.3761084501259890355840E+00  0.9253058095043029673832E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2161                             0                             0                             0                             0                             0                             0
  0.2745650093261855805827E-16  0.1252491859380355787579E+00  0.1890131146817441987196E-01 -0.4615100205552493258781E-16 -0.6572151062640398944126E+00  0.7537030609585891882674E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2162                             0                             0                             0                             0                             0                             0
  0.2346737414239508448532E-01  0.1252491859380355787579E+00  0.1951582628690196052901E-01 -0.3944577041850165499692E-01 -0.6572151062640398944126E+00  0.7526701371081740976621E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2163                             0                             0                             0                             0                             0                             0
  0.4687042584346291090869E-01  0.1252491859380355787579E+00  0.2135768640068080870265E-01 -0.7878342272212786323582E-01 -0.6572151062640397833903E+00  0.7495741967294053953452E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2164                             0                             0                             0                             0                             0                             0
  0.7014500896521726203137E-01  0.1252491859380355787579E+00  0.2442184339896513733947E-01 -0.1179051351402414515857E+00 -0.6572151062640398944126E+00  0.7444237255796649632700E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2165                             0                             0                             0                             0                             0                             0
  0.9322732949311773875678E-01  0.1252491859380355787579E+00  0.2869989864040983773563E-01 -0.1567036777784210910269E+00 -0.6572151062640398944126E+00  0.7372328407423692775424E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2166                             0                             0                             0                             0                             0                             0
  0.1160541203910297053392E+00  0.1252491859380355787579E+00  0.3418012627296179717362E-01 -0.1950727065281490368864E+00 -0.6572151062640398944126E+00  0.7280212519330252485261E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2167                             0                             0                             0                             0                             0                             0
  0.1385628150117729495694E+00  0.1252491859380355787579E+00  0.4084750537360637423490E-01 -0.2329070545486210397357E+00 -0.6572151062640397833903E+00  0.7168142074762695603596E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2168                             0                             0                             0                             0                             0                             0
  0.1606917185879521148273E+00  0.1252491859380355787579E+00  0.4868376111967237518385E-01 -0.2701030205217461732659E+00 -0.6572151062640400054349E+00  0.7036424251019661735285E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2169                             0                             0                             0                             0                             0                             0
  0.1823801773330260556083E+00  0.1252491859380355787579E+00  0.5766741487885135297731E-01 -0.3065586528902518037576E+00 -0.6572151062640397833903E+00  0.6885420077500434832274E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2170                             0                             0                             0                             0                             0                             0
  0.2035687446891208951527E+00  0.1252491859380355787579E+00  0.6777384308063555407031E-01 -0.3421740292998159960192E+00 -0.6572151062640397833903E+00  0.6715543446148460882128E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2171                             0                             0                             0                             0                             0                             0
  0.2241993442659127311334E+00  0.1252491859380355787579E+00  0.7897534470781297777364E-01 -0.3768515304792944831114E+00 -0.6572151062640398944126E+00  0.6527259977002296542636E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2172                             0                             0                             0                             0                             0                             0
  0.2442154290239771652349E+00  0.1252491859380355787579E+00  0.9124121722303052406389E-01 -0.4104961078083581571541E+00 -0.6572151062640398944126E+00  0.6321085741963445858715E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2173                             0                             0                             0                             0                             0                             0
  0.2635621362662931566057E+00  0.1252491859380355787579E+00  0.1045378407223142569471E+00 -0.4430155438391535915876E+00 -0.6572151062640398944126E+00  0.6097585850279155783582E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2174                             0                             0                             0                             0                             0                             0
  0.2821864380130827409943E+00  0.1252491859380355787579E+00  0.1188287700848896233374E+00 -0.4743207050579188455153E+00 -0.6572151062640397833903E+00  0.5857372899617246941872E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2175                             0                             0                             0                             0                             0                             0
  0.3000372863478172336116E+00  0.1252491859380355787579E+00  0.1340748348667240574805E+00 -0.5043257861937482378067E+00 -0.6572151062640398944126E+00  0.5601105296978484693327E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2176                             0                             0                             0                             0                             0                             0
  0.3170657533360084490148E+00  0.1252491859380355787579E+00  0.1502342466639914886350E+00 -0.5329485454048761283730E+00 -0.6572151062640398944126E+00  0.5329485454048762393953E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2177                             0                             0                             0                             0                             0                             0
  0.3332251651332759911917E+00  0.1252491859380355787579E+00  0.1672627136521827595494E+00 -0.5601105296978485803550E+00 -0.6572151062640398944126E+00  0.5043257861937482378067E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2178                             0                             0                             0                             0                             0                             0
  0.3484712299151104253347E+00  0.1252491859380355787579E+00  0.1851135619869173076779E+00 -0.5857372899617246941872E+00 -0.6572151062640398944126E+00  0.4743207050579187900041E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2179                             0                             0                             0                             0                             0                             0
  0.3627621592776857362139E+00  0.1252491859380355787579E+00  0.2037378637337068365554E+00 -0.6097585850279155783582E+00 -0.6572151062640398944126E+00  0.4430155438391535915876E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2180                             0                             0                             0                             0                             0                             0
  0.3760587827769694690971E+00  0.1252491859380355787579E+00  0.2230845709760228279261E+00 -0.6321085741963445858715E+00 -0.6572151062640398944126E+00  0.4104961078083581571541E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2181                             0                             0                             0                             0                             0                             0
  0.3883246552921869598762E+00  0.1252491859380355787579E+00  0.2431006557340872065165E+00 -0.6527259977002295432413E+00 -0.6572151062640398944126E+00  0.3768515304792945941337E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2182                             0                             0                             0                             0                             0                             0
  0.3995261569193644946019E+00  0.1252491859380355787579E+00  0.2637312553108791535195E+00 -0.6715543446148460882128E+00 -0.6572151062640400054349E+00  0.3421740292998159960192E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2183                             0                             0                             0                             0                             0                             0
  0.4096325851211486401837E+00  0.1252491859380355787579E+00  0.2849198226669739097972E+00 -0.6885420077500434832274E+00 -0.6572151062640398944126E+00  0.3065586528902518592687E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2184                             0                             0                             0                             0                             0                             0
  0.4186162388803276179772E+00  0.1252491859380355787579E+00  0.3066082814120478783337E+00 -0.7036424251019661735285E+00 -0.6572151062640400054349E+00  0.2701030205217461177547E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2185                             0                             0                             0                             0                             0                             0
  0.4264524946263936189261E+00  0.1252491859380355787579E+00  0.3287371849882270713472E+00 -0.7168142074762695603596E+00 -0.6572151062640397833903E+00  0.2329070545486209842245E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2186                             0                             0                             0                             0                             0                             0
  0.4331198737270381959874E+00  0.1252491859380355787579E+00  0.3512458796089703016996E+00 -0.7280212519330252485261E+00 -0.6572151062640398944126E+00  0.1950727065281489813753E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2187                             0                             0                             0                             0                             0                             0
  0.4386001013595902109365E+00  0.1252491859380355787579E+00  0.3740726705068823654265E+00 -0.7372328407423692775424E+00 -0.6572151062640398944126E+00  0.1567036777784208967379E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2188                             0                             0                             0                             0                             0                             0
  0.4428781566010348558216E+00  0.1252491859380355787579E+00  0.3971549910347827450074E+00 -0.7444237255796649632700E+00 -0.6572151062640398944126E+00  0.1179051351402414099523E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2189                             0                             0                             0                             0                             0                             0
  0.4459423135993191844584E+00  0.1252491859380355787579E+00  0.4204295741565370891912E+00 -0.7495741967294053953452E+00 -0.6572151062640396723680E+00  0.7878342272212780772467E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2190                             0                             0                             0                             0                             0                             0
  0.4477841737130980326320E+00  0.1252491859380355787579E+00  0.4438326258576050231675E+00 -0.7526701371081740976621E+00 -0.6572151062640398944126E+00  0.3944577041850143989121E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2191                             0                             0                             0                             0                             0                             0
  0.4483986885318255732891E+00  0.1252491859380355787579E+00  0.4672999999999998821387E+00 -0.7537030609585891882674E+00 -0.6572151062640398944126E+00  0.1673556984013367250935E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2192                             0                             0                             0                             0                             0                             0
  0.4477841737130980326320E+00  0.1252491859380355787579E+00  0.4907673741423949631546E+00 -0.7526701371081740976621E+00 -0.6572151062640398944126E+00 -0.3944577041850143989121E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2193                             0                             0                             0                             0                             0                             0
  0.4459423135993191844584E+00  0.1252491859380355787579E+00  0.5141704258434628416197E+00 -0.7495741967294053953452E+00 -0.6572151062640396723680E+00 -0.7878342272212780772467E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2194                             0                             0                             0                             0                             0                             0
  0.4428781566010348558216E+00  0.1252491859380355787579E+00  0.5374450089652171858035E+00 -0.7444237255796649632700E+00 -0.6572151062640398944126E+00 -0.1179051351402414099523E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2195                             0                             0                             0                             0                             0                             0
  0.4386001013595901554254E+00  0.1252491859380355787579E+00  0.5605273294931176764067E+00 -0.7372328407423692775424E+00 -0.6572151062640397833903E+00 -0.1567036777784210632714E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2196                             0                             0                             0                             0                             0                             0
  0.4331198737270381959874E+00  0.1252491859380355787579E+00  0.5833541203910297401336E+00 -0.7280212519330252485261E+00 -0.6572151062640398944126E+00 -0.1950727065281489813753E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2197                             0                             0                             0                             0                             0                             0
  0.4264524946263936189261E+00  0.1252491859380355787579E+00  0.6058628150117728594637E+00 -0.7168142074762695603596E+00 -0.6572151062640397833903E+00 -0.2329070545486209842245E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2198                             0                             0                             0                             0                             0                             0
  0.4186162388803276179772E+00  0.1252491859380355787579E+00  0.6279917185879521079883E+00 -0.7036424251019661735285E+00 -0.6572151062640400054349E+00 -0.2701030205217461177547E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2199                             0                             0                             0                             0                             0                             0
  0.4096325851211486956949E+00  0.1252491859380355787579E+00  0.6496801773330260765249E+00 -0.6885420077500435942497E+00 -0.6572151062640400054349E+00 -0.3065586528902517482464E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2200                             0                             0                             0                             0                             0                             0
  0.3995261569193644946019E+00  0.1252491859380355787579E+00  0.6708687446891208328026E+00 -0.6715543446148460882128E+00 -0.6572151062640400054349E+00 -0.3421740292998159960192E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2201                             0                             0                             0                             0                             0                             0
  0.3883246552921870153874E+00  0.1252491859380355787579E+00  0.6914993442659127520500E+00 -0.6527259977002296542636E+00 -0.6572151062640398944126E+00 -0.3768515304792944831114E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2202                             0                             0                             0                             0                             0                             0
  0.3760587827769695246083E+00  0.1252491859380355787579E+00  0.7115154290239771306403E+00 -0.6321085741963446968938E+00 -0.6572151062640398944126E+00 -0.4104961078083579906206E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2203                             0                             0                             0                             0                             0                             0
  0.3627621592776857362139E+00  0.1252491859380355787579E+00  0.7308621362662931497667E+00 -0.6097585850279155783582E+00 -0.6572151062640398944126E+00 -0.4430155438391535915876E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2204                             0                             0                             0                             0                             0                             0
  0.3484712299151104808459E+00  0.1252491859380355787579E+00  0.7494864380130825676218E+00 -0.5857372899617248052095E+00 -0.6572151062640398944126E+00 -0.4743207050579186789818E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2205                             0                             0                             0                             0                             0                             0
  0.3332251651332761022140E+00  0.1252491859380355787579E+00  0.7673372863478171712615E+00 -0.5601105296978488023996E+00 -0.6572151062640398944126E+00 -0.5043257861937481267844E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2206                             0                             0                             0                             0                             0                             0
  0.3170657533360085045260E+00  0.1252491859380355787579E+00  0.7843657533360084421759E+00 -0.5329485454048762393953E+00 -0.6572151062640398944126E+00 -0.5329485454048761283730E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2207                             0                             0                             0                             0                             0                             0
  0.3000372863478172891227E+00  0.1252491859380355787579E+00  0.8005251651332758733304E+00 -0.5043257861937483488290E+00 -0.6572151062640398944126E+00 -0.5601105296978484693327E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2208                             0                             0                             0                             0                             0                             0
  0.2821864380130826854831E+00  0.1252491859380355787579E+00  0.8157712299151104184958E+00 -0.4743207050579187900041E+00 -0.6572151062640398944126E+00 -0.5857372899617246941872E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2209                             0                             0                             0                             0                             0                             0
  0.2635621362662931566057E+00  0.1252491859380355787579E+00  0.8300621592776857848861E+00 -0.4430155438391535915876E+00 -0.6572151062640398944126E+00 -0.6097585850279155783582E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2210                             0                             0                             0                             0                             0                             0
  0.2442154290239772207460E+00  0.1252491859380355787579E+00  0.8433587827769694067470E+00 -0.4104961078083582126652E+00 -0.6572151062640398944126E+00 -0.6321085741963444748492E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2211                             0                             0                             0                             0                             0                             0
  0.2241993442659127311334E+00  0.1252491859380355787579E+00  0.8556246552921870085484E+00 -0.3768515304792944831114E+00 -0.6572151062640398944126E+00 -0.6527259977002296542636E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2212                             0                             0                             0                             0                             0                             0
  0.2035687446891208951527E+00  0.1252491859380355787579E+00  0.8668261569193644877629E+00 -0.3421740292998159960192E+00 -0.6572151062640397833903E+00 -0.6715543446148460882128E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2213                             0                             0                             0                             0                             0                             0
  0.1823801773330259445860E+00  0.1252491859380355787579E+00  0.8769325851211486888559E+00 -0.3065586528902516372241E+00 -0.6572151062640398944126E+00 -0.6885420077500435942497E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2214                             0                             0                             0                             0                             0                             0
  0.1606917185879520315606E+00  0.1252491859380355787579E+00  0.8859162388803276666494E+00 -0.2701030205217460067324E+00 -0.6572151062640398944126E+00 -0.7036424251019661735285E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2215                             0                             0                             0                             0                             0                             0
  0.1385628150117729495694E+00  0.1252491859380355787579E+00  0.8937524946263936120872E+00 -0.2329070545486210397357E+00 -0.6572151062640397833903E+00 -0.7168142074762695603596E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2216                             0                             0                             0                             0                             0                             0
  0.1160541203910296081947E+00  0.1252491859380355787579E+00  0.9004198737270381336373E+00 -0.1950727065281488703530E+00 -0.6572151062640397833903E+00 -0.7280212519330252485261E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2217                             0                             0                             0                             0                             0                             0
  0.9322732949311764161227E-01  0.1252491859380355787579E+00  0.9059001013595902040976E+00 -0.1567036777784209244935E+00 -0.6572151062640398944126E+00 -0.7372328407423692775424E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2218                             0                             0                             0                             0                             0                             0
  0.7014500896521726203137E-01  0.1252491859380355787579E+00  0.9101781566010348489826E+00 -0.1179051351402414515857E+00 -0.6572151062640398944126E+00 -0.7444237255796649632700E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2219                             0                             0                             0                             0                             0                             0
  0.4687042584346281376417E-01  0.1252491859380355787579E+00  0.9132423135993192886417E+00 -0.7878342272212769670237E-01 -0.6572151062640398944126E+00 -0.7495741967294053953452E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2220                             0                             0                             0                             0                             0                             0
  0.2346737414239498387136E-01  0.1252491859380355787579E+00  0.9150841737130980257930E+00 -0.3944577041850148846347E-01 -0.6572151062640398944126E+00 -0.7526701371081740976621E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2221                             0                             0                             0                             0                             0                             0
  0.2265855202205213012420E-15  0.1252491859380355787579E+00  0.9156986885318255664501E+00 -0.3808623988581983889378E-15 -0.6572151062640398944126E+00 -0.7537030609585891882674E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2222                             0                             0                             0                             0                             0                             0
 -0.2346737414239492836021E-01  0.1252491859380355787579E+00  0.9150841737130980257930E+00  0.3944577041850139131896E-01 -0.6572151062640398944126E+00 -0.7526701371081740976621E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2223                             0                             0                             0                             0                             0                             0
 -0.4687042584346275825302E-01  0.1252491859380355787579E+00  0.9132423135993192886417E+00  0.7878342272212759955785E-01 -0.6572151062640398944126E+00 -0.7495741967294053953452E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2224                             0                             0                             0                             0                             0                             0
 -0.7014500896521720652022E-01  0.1252491859380355787579E+00  0.9101781566010348489826E+00  0.1179051351402413683189E+00 -0.6572151062640398944126E+00 -0.7444237255796649632700E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2225                             0                             0                             0                             0                             0                             0
 -0.9322732949311758610111E-01  0.1252491859380355787579E+00  0.9059001013595902040976E+00  0.1567036777784208412267E+00 -0.6572151062640398944126E+00 -0.7372328407423692775424E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2226                             0                             0                             0                             0                             0                             0
 -0.1160541203910295665613E+00  0.1252491859380355787579E+00  0.9004198737270382446596E+00  0.1950727065281487870863E+00 -0.6572151062640400054349E+00 -0.7280212519330253595484E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2227                             0                             0                             0                             0                             0                             0
 -0.1385628150117728940582E+00  0.1252491859380355787579E+00  0.8937524946263937231095E+00  0.2329070545486209564690E+00 -0.6572151062640400054349E+00 -0.7168142074762696713819E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2228                             0                             0                             0                             0                             0                             0
 -0.1606917185879519760494E+00  0.1252491859380355787579E+00  0.8859162388803276666494E+00  0.2701030205217458957101E+00 -0.6572151062640397833903E+00 -0.7036424251019661735285E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2229                             0                             0                             0                             0                             0                             0
 -0.1823801773330260833639E+00  0.1252491859380355787579E+00  0.8769325851211486888559E+00  0.3065586528902518037576E+00 -0.6572151062640397833903E+00 -0.6885420077500434832274E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2230                             0                             0                             0                             0                             0                             0
 -0.2035687446891208396416E+00  0.1252491859380355787579E+00  0.8668261569193644877629E+00  0.3421740292998159405080E+00 -0.6572151062640398944126E+00 -0.6715543446148460882128E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2231                             0                             0                             0                             0                             0                             0
 -0.2241993442659126756222E+00  0.1252491859380355787579E+00  0.8556246552921870085484E+00  0.3768515304792944276002E+00 -0.6572151062640398944126E+00 -0.6527259977002296542636E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2232                             0                             0                             0                             0                             0                             0
 -0.2442154290239771652349E+00  0.1252491859380355787579E+00  0.8433587827769694067470E+00  0.4104961078083581571541E+00 -0.6572151062640397833903E+00 -0.6321085741963444748492E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2233                             0                             0                             0                             0                             0                             0
 -0.2635621362662931010945E+00  0.1252491859380355787579E+00  0.8300621592776857848861E+00  0.4430155438391535360765E+00 -0.6572151062640397833903E+00 -0.6097585850279155783582E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2234                             0                             0                             0                             0                             0                             0
 -0.2821864380130826299720E+00  0.1252491859380355787579E+00  0.8157712299151105295181E+00  0.4743207050579186789818E+00 -0.6572151062640398944126E+00 -0.5857372899617248052095E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2235                             0                             0                             0                             0                             0                             0
 -0.3000372863478172336116E+00  0.1252491859380355787579E+00  0.8005251651332759843527E+00  0.5043257861937482378067E+00 -0.6572151062640398944126E+00 -0.5601105296978485803550E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2236                             0                             0                             0                             0                             0                             0
 -0.3170657533360084490148E+00  0.1252491859380355787579E+00  0.7843657533360084421759E+00  0.5329485454048761283730E+00 -0.6572151062640398944126E+00 -0.5329485454048762393953E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2237                             0                             0                             0                             0                             0                             0
 -0.3332251651332758801694E+00  0.1252491859380355787579E+00  0.7673372863478172822838E+00  0.5601105296978484693327E+00 -0.6572151062640397833903E+00 -0.5043257861937483488290E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2238                             0                             0                             0                             0                             0                             0
 -0.3484712299151103143124E+00  0.1252491859380355787579E+00  0.7494864380130827896664E+00  0.5857372899617245831649E+00 -0.6572151062640398944126E+00 -0.4743207050579190120487E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2239                             0                             0                             0                             0                             0                             0
 -0.3627621592776856807028E+00  0.1252491859380355787579E+00  0.7308621362662932607890E+00  0.6097585850279155783582E+00 -0.6572151062640398944126E+00 -0.4430155438391537026099E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2240                             0                             0                             0                             0                             0                             0
 -0.3760587827769695246083E+00  0.1252491859380355787579E+00  0.7115154290239771306403E+00  0.6321085741963446968938E+00 -0.6572151062640398944126E+00 -0.4104961078083580461318E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2241                             0                             0                             0                             0                             0                             0
 -0.3883246552921869043651E+00  0.1252491859380355787579E+00  0.6914993442659129740946E+00  0.6527259977002294322190E+00 -0.6572151062640398944126E+00 -0.3768515304792948716894E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2242                             0                             0                             0                             0                             0                             0
 -0.3995261569193644390907E+00  0.1252491859380355787579E+00  0.6708687446891209438249E+00  0.6715543446148460882128E+00 -0.6572151062640397833903E+00 -0.3421740292998160515303E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2243                             0                             0                             0                             0                             0                             0
 -0.4096325851211485291614E+00  0.1252491859380355787579E+00  0.6496801773330262985695E+00  0.6885420077500432611828E+00 -0.6572151062640398944126E+00 -0.3065586528902522478468E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2244                             0                             0                             0                             0                             0                             0
 -0.4186162388803277289995E+00  0.1252491859380355787579E+00  0.6279917185879518859437E+00  0.7036424251019662845508E+00 -0.6572151062640398944126E+00 -0.2701030205217457291766E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2245                             0                             0                             0                             0                             0                             0
 -0.4264524946263936189261E+00  0.1252491859380355787579E+00  0.6058628150117729704860E+00  0.7168142074762695603596E+00 -0.6572151062640397833903E+00 -0.2329070545486210674913E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2246                             0                             0                             0                             0                             0                             0
 -0.4331198737270381959874E+00  0.1252491859380355787579E+00  0.5833541203910296291113E+00  0.7280212519330252485261E+00 -0.6572151062640397833903E+00 -0.1950727065281488981086E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2247                             0                             0                             0                             0                             0                             0
 -0.4386001013595901554254E+00  0.1252491859380355787579E+00  0.5605273294931178984513E+00  0.7372328407423692775424E+00 -0.6572151062640398944126E+00 -0.1567036777784213130715E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2248                             0                             0                             0                             0                             0                             0
 -0.4428781566010348003104E+00  0.1252491859380355787579E+00  0.5374450089652172968258E+00  0.7444237255796648522477E+00 -0.6572151062640397833903E+00 -0.1179051351402414932190E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2249                             0                             0                             0                             0                             0                             0
 -0.4459423135993191844584E+00  0.1252491859380355787579E+00  0.5141704258434631746866E+00  0.7495741967294053953452E+00 -0.6572151062640397833903E+00 -0.7878342272212840446954E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2250                             0                             0                             0                             0                             0                             0
 -0.4477841737130980881432E+00  0.1252491859380355787579E+00  0.4907673741423947966211E+00  0.7526701371081742086844E+00 -0.6572151062640398944126E+00 -0.3944577041850119702993E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2251                             0                             0                             0                             0                             0                             0
 -0.4483986885318255732891E+00  0.1252491859380355787579E+00  0.4673000000000000486722E+00  0.7537030609585891882674E+00 -0.6572151062640398944126E+00 -0.9230200411104986517562E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2252                             0                             0                             0                             0                             0                             0
 -0.4477841737130980326320E+00  0.1252491859380355787579E+00  0.4438326258576049121451E+00  0.7526701371081740976621E+00 -0.6572151062640398944126E+00  0.3944577041850167581361E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2253                             0                             0                             0                             0                             0                             0
 -0.4459423135993192399695E+00  0.1252491859380355787579E+00  0.4204295741565372557247E+00  0.7495741967294053953452E+00 -0.6572151062640398944126E+00  0.7878342272212755792449E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2254                             0                             0                             0                             0                             0                             0
 -0.4428781566010348558216E+00  0.1252491859380355787579E+00  0.3971549910347828005186E+00  0.7444237255796649632700E+00 -0.6572151062640398944126E+00  0.1179051351402413128078E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2255                             0                             0                             0                             0                             0                             0
 -0.4386001013595901554254E+00  0.1252491859380355787579E+00  0.3740726705068821988931E+00  0.7372328407423692775424E+00 -0.6572151062640398944126E+00  0.1567036777784211465381E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2256                             0                             0                             0                             0                             0                             0
 -0.4331198737270381404763E+00  0.1252491859380355787579E+00  0.3512458796089700796550E+00  0.7280212519330252485261E+00 -0.6572151062640398944126E+00  0.1950727065281493699533E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2257                             0                             0                             0                             0                             0                             0
 -0.4264524946263936744373E+00  0.1252491859380355787579E+00  0.3287371849882271268584E+00  0.7168142074762696713819E+00 -0.6572151062640398944126E+00  0.2329070545486209009578E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2258                             0                             0                             0                             0                             0                             0
 -0.4186162388803277289995E+00  0.1252491859380355787579E+00  0.3066082814120482114006E+00  0.7036424251019662845508E+00 -0.6572151062640398944126E+00  0.2701030205217455626432E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2259                             0                             0                             0                             0                             0                             0
 -0.4096325851211487512060E+00  0.1252491859380355787579E+00  0.2849198226669741318418E+00  0.6885420077500435942497E+00 -0.6572151062640398944126E+00  0.3065586528902514706907E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2260                             0                             0                             0                             0                             0                             0
 -0.3995261569193644946019E+00  0.1252491859380355787579E+00  0.2637312553108791535195E+00  0.6715543446148460882128E+00 -0.6572151062640398944126E+00  0.3421740292998159405080E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2261                             0                             0                             0                             0                             0                             0
 -0.3883246552921869598762E+00  0.1252491859380355787579E+00  0.2431006557340871510053E+00  0.6527259977002295432413E+00 -0.6572151062640398944126E+00  0.3768515304792947051560E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2262                             0                             0                             0                             0                             0                             0
 -0.3760587827769695801194E+00  0.1252491859380355787579E+00  0.2230845709760229667040E+00  0.6321085741963446968938E+00 -0.6572151062640398944126E+00  0.4104961078083578795983E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2263                             0                             0                             0                             0                             0                             0
 -0.3627621592776857917251E+00  0.1252491859380355787579E+00  0.2037378637337068920665E+00  0.6097585850279156893805E+00 -0.6572151062640400054349E+00  0.4430155438391535360765E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2264                             0                             0                             0                             0                             0                             0
 -0.3484712299151105918682E+00  0.1252491859380355787579E+00  0.1851135619869175297225E+00  0.5857372899617250272541E+00 -0.6572151062640398944126E+00  0.4743207050579183459149E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2265                             0                             0                             0                             0                             0                             0
 -0.3332251651332758246582E+00  0.1252491859380355787579E+00  0.1672627136521825930160E+00  0.5601105296978483583104E+00 -0.6572151062640398944126E+00  0.5043257861937485708737E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2266                             0                             0                             0                             0                             0                             0
 -0.3170657533360085600371E+00  0.1252491859380355787579E+00  0.1502342466639915441462E+00  0.5329485454048763504176E+00 -0.6572151062640400054349E+00  0.5329485454048761283730E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2267                             0                             0                             0                             0                             0                             0
 -0.3000372863478172336116E+00  0.1252491859380355787579E+00  0.1340748348667239464582E+00  0.5043257861937482378067E+00 -0.6572151062640398944126E+00  0.5601105296978486913773E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2268                             0                             0                             0                             0                             0                             0
 -0.2821864380130829075277E+00  0.1252491859380355787579E+00  0.1188287700848897343597E+00  0.4743207050579191230710E+00 -0.6572151062640398944126E+00  0.5857372899617244721426E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2269                             0                             0                             0                             0                             0                             0
 -0.2635621362662932121168E+00  0.1252491859380355787579E+00  0.1045378407223143124583E+00  0.4430155438391537026099E+00 -0.6572151062640398944126E+00  0.6097585850279155783582E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2270                             0                             0                             0                             0                             0                             0
 -0.2442154290239774705462E+00  0.1252491859380355787579E+00  0.9124121722303074610849E-01  0.4104961078083586567544E+00 -0.6572151062640398944126E+00  0.6321085741963442528046E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2271                             0                             0                             0                             0                             0                             0
 -0.2241993442659126201111E+00  0.1252491859380355787579E+00  0.7897534470781292226249E-01  0.3768515304792943165779E+00 -0.6572151062640397833903E+00  0.6527259977002296542636E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2272                             0                             0                             0                             0                             0                             0
 -0.2035687446891209229083E+00  0.1252491859380355787579E+00  0.6777384308063555407031E-01  0.3421740292998161070415E+00 -0.6572151062640398944126E+00  0.6715543446148460882128E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2273                             0                             0                             0                             0                             0                             0
 -0.1823801773330260000971E+00  0.1252491859380355787579E+00  0.5766741487885129746616E-01  0.3065586528902516927353E+00 -0.6572151062640400054349E+00  0.6885420077500435942497E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2274                             0                             0                             0                             0                             0                             0
 -0.1606917185879522813607E+00  0.1252491859380355787579E+00  0.4868376111967237518385E-01  0.2701030205217463953105E+00 -0.6572151062640398944126E+00  0.7036424251019660625062E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2275                             0                             0                             0                             0                             0                             0
 -0.1385628150117730050805E+00  0.1252491859380355787579E+00  0.4084750537360637423490E-01  0.2329070545486211230024E+00 -0.6572151062640398944126E+00  0.7168142074762695603596E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2276                             0                             0                             0                             0                             0                             0
 -0.1160541203910296637059E+00  0.1252491859380355787579E+00  0.3418012627296179717362E-01  0.1950727065281489536197E+00 -0.6572151062640397833903E+00  0.7280212519330252485261E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2277                             0                             0                             0                             0                             0                             0
 -0.9322732949311750283439E-01  0.1252491859380355787579E+00  0.2869989864040978222448E-01  0.1567036777784207024489E+00 -0.6572151062640397833903E+00  0.7372328407423692775424E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2278                             0                             0                             0                             0                             0                             0
 -0.7014500896521731754252E-01  0.1252491859380355787579E+00  0.2442184339896519285062E-01  0.1179051351402415348524E+00 -0.6572151062640398944126E+00  0.7444237255796648522477E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2279                             0                             0                             0                             0                             0                             0
 -0.4687042584346286927532E-01  0.1252491859380355787579E+00  0.2135768640068075319149E-01  0.7878342272212779384688E-01 -0.6572151062640398944126E+00  0.7495741967294053953452E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2280                             0                             0                             0                             0                             0                             0
 -0.2346737414239523714099E-01  0.1252491859380355787579E+00  0.1951582628690196052901E-01  0.3944577041850191173600E-01 -0.6572151062640398944126E+00  0.7526701371081740976621E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2281                             0                             0                             0                             0                             0                             0
  0.2618816711648114258985E-16  0.1437667757714512495326E+00  0.3961477459926626698561E-01 -0.2806759479206384675450E-16 -0.8887570259422461482757E+00  0.4583786086176944718495E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2282                             0                             0                             0                             0                             0                             0
  0.2238331524232642713579E-01  0.1437667757714512495326E+00  0.4020090233666023804560E-01 -0.2398968280331719576948E-01 -0.8887570259422461482757E+00  0.4577504166653371120432E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2283                             0                             0                             0                             0                             0                             0
  0.4470527937341868540688E-01  0.1437667757714512495326E+00  0.4195767901345509587330E-01 -0.4791361155357277967770E-01 -0.8887570259422461482757E+00  0.4558675626387414525631E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2284                             0                             0                             0                             0                             0                             0
  0.6690470944117436757903E-01  0.1437667757714512495326E+00  0.4488028942689181732817E-01 -0.7170621242499441994056E-01 -0.8887570259422461482757E+00  0.4527352073099187856897E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2285                             0                             0                             0                             0                             0                             0
  0.8892075835084110868589E-01  0.1437667757714512495326E+00  0.4896072290497543999521E-01 -0.9530227155239685832289E-01 -0.8887570259422461482757E+00  0.4483619362470979696766E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2286                             0                             0                             0                             0                             0                             0
  0.1106930816426742458791E+00  0.1437667757714512495326E+00  0.5418779526316985784007E-01 -0.1186371137778537698804E+00 -0.8887570259422461482757E+00  0.4427597362822799920146E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2287                             0                             0                             0                             0                             0                             0
  0.1321620028919066602846E+00  0.1437667757714512495326E+00  0.6054717945947069024371E-01 -0.1416467799208103450770E+00 -0.8887570259422460372534E+00  0.4359439626561641412117E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2288                             0                             0                             0                             0                             0                             0
  0.1532686772776805650409E+00  0.1437667757714512495326E+00  0.6802144486383115973283E-01 -0.1642682020857509084255E+00 -0.8887570259422462592980E+00  0.4279332969305011391548E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2289                             0                             0                             0                             0                             0                             0
  0.1739552528726114044577E+00  0.1437667757714512495326E+00  0.7659010503430779825962E-01 -0.1864393765269171110432E+00 -0.8887570259422460372534E+00  0.4187496957832303468017E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2290                             0                             0                             0                             0                             0                             0
  0.1941650292108998143714E+00  0.1437667757714512495326E+00  0.8622967386897362196407E-01 -0.2080995335962652625916E+00 -0.8887570259422460372534E+00  0.4084183308267521628210E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2291                             0                             0                             0                             0                             0                             0
  0.2138426127003668075766E+00  0.1437667757714512495326E+00  0.9691372997969088798342E-01 -0.2291893043088471804136E+00 -0.8887570259422461482757E+00  0.3969675196142880557737E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2292                             0                             0                             0                             0                             0                             0
  0.2329340684524399684996E+00  0.1437667757714512495326E+00  0.1086129891112999623637E+00 -0.2496508830690719049628E+00 -0.8887570259422461482757E+00  0.3844286480234350711349E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2293                             0                             0                             0                             0                             0                             0
  0.2513870681139335205856E+00  0.1437667757714512495326E+00  0.1212953844077264697887E+00 -0.2694281861118243415198E+00 -0.8887570259422461482757E+00  0.3708360842296575810018E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
