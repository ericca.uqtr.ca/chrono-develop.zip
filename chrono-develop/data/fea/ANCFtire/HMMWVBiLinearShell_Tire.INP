                          2203                             1                             2                          2203                          2204                          2323                          2324
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2204                             1                             2                          2204                          2205                          2324                          2325
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2205                             1                             2                          2205                          2206                          2325                          2326
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2206                             1                             2                          2206                          2207                          2326                          2327
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2207                             1                             2                          2207                          2208                          2327                          2328
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2208                             1                             2                          2208                          2209                          2328                          2329
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2209                             1                             2                          2209                          2210                          2329                          2330
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2210                             1                             2                          2210                          2211                          2330                          2331
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2211                             1                             2                          2211                          2212                          2331                          2332
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2212                             1                             2                          2212                          2213                          2332                          2333
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2213                             1                             2                          2213                          2214                          2333                          2334
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2214                             1                             2                          2214                          2215                          2334                          2335
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2215                             1                             2                          2215                          2216                          2335                          2336
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2216                             1                             2                          2216                          2217                          2336                          2337
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2217                             1                             2                          2217                          2218                          2337                          2338
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2218                             1                             2                          2218                          2219                          2338                          2339
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2219                             1                             2                          2219                          2220                          2339                          2340
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2220                             1                             2                          2220                          2221                          2340                          2341
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2221                             1                             2                          2221                          2222                          2341                          2342
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2222                             1                             2                          2222                          2223                          2342                          2343
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2223                             1                             2                          2223                          2224                          2343                          2344
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2224                             1                             2                          2224                          2225                          2344                          2345
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2225                             1                             2                          2225                          2226                          2345                          2346
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2226                             1                             2                          2226                          2227                          2346                          2347
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2227                             1                             2                          2227                          2228                          2347                          2348
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2228                             1                             2                          2228                          2229                          2348                          2349
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2229                             1                             2                          2229                          2230                          2349                          2350
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2230                             1                             2                          2230                          2231                          2350                          2351
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2231                             1                             2                          2231                          2232                          2351                          2352
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2232                             1                             2                          2232                          2233                          2352                          2353
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2233                             1                             2                          2233                          2234                          2353                          2354
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2234                             1                             2                          2234                          2235                          2354                          2355
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2235                             1                             2                          2235                          2236                          2355                          2356
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2236                             1                             2                          2236                          2237                          2356                          2357
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2237                             1                             2                          2237                          2238                          2357                          2358
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2238                             1                             2                          2238                          2239                          2358                          2359
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2239                             1                             2                          2239                          2240                          2359                          2360
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2240                             1                             2                          2240                          2241                          2360                          2361
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2241                             1                             2                          2241                          2242                          2361                          2362
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2242                             1                             2                          2242                          2243                          2362                          2363
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2243                             1                             2                          2243                          2244                          2363                          2364
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2244                             1                             2                          2244                          2245                          2364                          2365
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2245                             1                             2                          2245                          2246                          2365                          2366
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2246                             1                             2                          2246                          2247                          2366                          2367
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2247                             1                             2                          2247                          2248                          2367                          2368
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2248                             1                             2                          2248                          2249                          2368                          2369
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2249                             1                             2                          2249                          2250                          2369                          2370
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2250                             1                             2                          2250                          2251                          2370                          2371
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2251                             1                             2                          2251                          2252                          2371                          2372
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2252                             1                             2                          2252                          2253                          2372                          2373
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2253                             1                             2                          2253                          2254                          2373                          2374
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2254                             1                             2                          2254                          2255                          2374                          2375
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2255                             1                             2                          2255                          2256                          2375                          2376
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2256                             1                             2                          2256                          2257                          2376                          2377
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2257                             1                             2                          2257                          2258                          2377                          2378
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2258                             1                             2                          2258                          2259                          2378                          2379
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2259                             1                             2                          2259                          2260                          2379                          2380
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2260                             1                             2                          2260                          2261                          2380                          2381
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2261                             1                             2                          2261                          2262                          2381                          2382
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2262                             1                             2                          2262                          2263                          2382                          2383
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2263                             1                             2                          2263                          2264                          2383                          2384
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2264                             1                             2                          2264                          2265                          2384                          2385
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2265                             1                             2                          2265                          2266                          2385                          2386
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2266                             1                             2                          2266                          2267                          2386                          2387
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2267                             1                             2                          2267                          2268                          2387                          2388
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2268                             1                             2                          2268                          2269                          2388                          2389
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2269                             1                             2                          2269                          2270                          2389                          2390
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2270                             1                             2                          2270                          2271                          2390                          2391
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2271                             1                             2                          2271                          2272                          2391                          2392
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2272                             1                             2                          2272                          2273                          2392                          2393
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2273                             1                             2                          2273                          2274                          2393                          2394
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2274                             1                             2                          2274                          2275                          2394                          2395
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2275                             1                             2                          2275                          2276                          2395                          2396
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2276                             1                             2                          2276                          2277                          2396                          2397
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2277                             1                             2                          2277                          2278                          2397                          2398
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2278                             1                             2                          2278                          2279                          2398                          2399
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2279                             1                             2                          2279                          2280                          2399                          2400
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2280                             1                             2                          2280                          2161                          2400                          2281
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2281                             1                             2                          2281                          2282                          2401                          2402
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2282                             1                             2                          2282                          2283                          2402                          2403
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2283                             1                             2                          2283                          2284                          2403                          2404
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2284                             1                             2                          2284                          2285                          2404                          2405
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2285                             1                             2                          2285                          2286                          2405                          2406
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2286                             1                             2                          2286                          2287                          2406                          2407
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2287                             1                             2                          2287                          2288                          2407                          2408
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2288                             1                             2                          2288                          2289                          2408                          2409
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2289                             1                             2                          2289                          2290                          2409                          2410
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2290                             1                             2                          2290                          2291                          2410                          2411
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2291                             1                             2                          2291                          2292                          2411                          2412
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2292                             1                             2                          2292                          2293                          2412                          2413
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2293                             1                             2                          2293                          2294                          2413                          2414
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2294                             1                             2                          2294                          2295                          2414                          2415
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2295                             1                             2                          2295                          2296                          2415                          2416
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2296                             1                             2                          2296                          2297                          2416                          2417
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2297                             1                             2                          2297                          2298                          2417                          2418
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2298                             1                             2                          2298                          2299                          2418                          2419
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2299                             1                             2                          2299                          2300                          2419                          2420
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2300                             1                             2                          2300                          2301                          2420                          2421
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2301                             1                             2                          2301                          2302                          2421                          2422
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2302                             1                             2                          2302                          2303                          2422                          2423
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2303                             1                             2                          2303                          2304                          2423                          2424
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2304                             1                             2                          2304                          2305                          2424                          2425
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2305                             1                             2                          2305                          2306                          2425                          2426
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2306                             1                             2                          2306                          2307                          2426                          2427
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2307                             1                             2                          2307                          2308                          2427                          2428
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2308                             1                             2                          2308                          2309                          2428                          2429
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2309                             1                             2                          2309                          2310                          2429                          2430
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2310                             1                             2                          2310                          2311                          2430                          2431
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2311                             1                             2                          2311                          2312                          2431                          2432
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2312                             1                             2                          2312                          2313                          2432                          2433
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2313                             1                             2                          2313                          2314                          2433                          2434
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2314                             1                             2                          2314                          2315                          2434                          2435
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2315                             1                             2                          2315                          2316                          2435                          2436
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2316                             1                             2                          2316                          2317                          2436                          2437
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2317                             1                             2                          2317                          2318                          2437                          2438
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2318                             1                             2                          2318                          2319                          2438                          2439
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2319                             1                             2                          2319                          2320                          2439                          2440
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2320                             1                             2                          2320                          2321                          2440                          2441
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2321                             1                             2                          2321                          2322                          2441                          2442
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2322                             1                             2                          2322                          2323                          2442                          2443
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2323                             1                             2                          2323                          2324                          2443                          2444
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2324                             1                             2                          2324                          2325                          2444                          2445
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2325                             1                             2                          2325                          2326                          2445                          2446
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2326                             1                             2                          2326                          2327                          2446                          2447
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2327                             1                             2                          2327                          2328                          2447                          2448
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2328                             1                             2                          2328                          2329                          2448                          2449
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2329                             1                             2                          2329                          2330                          2449                          2450
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2330                             1                             2                          2330                          2331                          2450                          2451
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2331                             1                             2                          2331                          2332                          2451                          2452
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2332                             1                             2                          2332                          2333                          2452                          2453
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2333                             1                             2                          2333                          2334                          2453                          2454
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2334                             1                             2                          2334                          2335                          2454                          2455
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2335                             1                             2                          2335                          2336                          2455                          2456
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2336                             1                             2                          2336                          2337                          2456                          2457
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2337                             1                             2                          2337                          2338                          2457                          2458
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2338                             1                             2                          2338                          2339                          2458                          2459
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2339                             1                             2                          2339                          2340                          2459                          2460
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2340                             1                             2                          2340                          2341                          2460                          2461
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2341                             1                             2                          2341                          2342                          2461                          2462
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2342                             1                             2                          2342                          2343                          2462                          2463
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2343                             1                             2                          2343                          2344                          2463                          2464
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2344                             1                             2                          2344                          2345                          2464                          2465
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2345                             1                             2                          2345                          2346                          2465                          2466
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2346                             1                             2                          2346                          2347                          2466                          2467
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2347                             1                             2                          2347                          2348                          2467                          2468
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2348                             1                             2                          2348                          2349                          2468                          2469
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2349                             1                             2                          2349                          2350                          2469                          2470
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2350                             1                             2                          2350                          2351                          2470                          2471
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2351                             1                             2                          2351                          2352                          2471                          2472
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2352                             1                             2                          2352                          2353                          2472                          2473
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2353                             1                             2                          2353                          2354                          2473                          2474
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2354                             1                             2                          2354                          2355                          2474                          2475
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2355                             1                             2                          2355                          2356                          2475                          2476
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2356                             1                             2                          2356                          2357                          2476                          2477
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2357                             1                             2                          2357                          2358                          2477                          2478
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2358                             1                             2                          2358                          2359                          2478                          2479
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2359                             1                             2                          2359                          2360                          2479                          2480
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2360                             1                             2                          2360                          2361                          2480                          2481
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2361                             1                             2                          2361                          2362                          2481                          2482
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2362                             1                             2                          2362                          2363                          2482                          2483
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2363                             1                             2                          2363                          2364                          2483                          2484
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2364                             1                             2                          2364                          2365                          2484                          2485
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2365                             1                             2                          2365                          2366                          2485                          2486
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2366                             1                             2                          2366                          2367                          2486                          2487
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2367                             1                             2                          2367                          2368                          2487                          2488
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2368                             1                             2                          2368                          2369                          2488                          2489
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2369                             1                             2                          2369                          2370                          2489                          2490
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2370                             1                             2                          2370                          2371                          2490                          2491
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2371                             1                             2                          2371                          2372                          2491                          2492
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2372                             1                             2                          2372                          2373                          2492                          2493
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2373                             1                             2                          2373                          2374                          2493                          2494
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2374                             1                             2                          2374                          2375                          2494                          2495
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2375                             1                             2                          2375                          2376                          2495                          2496
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2376                             1                             2                          2376                          2377                          2496                          2497
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2377                             1                             2                          2377                          2378                          2497                          2498
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2378                             1                             2                          2378                          2379                          2498                          2499
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2379                             1                             2                          2379                          2380                          2499                          2500
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2380                             1                             2                          2380                          2381                          2500                          2501
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2381                             1                             2                          2381                          2382                          2501                          2502
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2382                             1                             2                          2382                          2383                          2502                          2503
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2383                             1                             2                          2383                          2384                          2503                          2504
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2384                             1                             2                          2384                          2385                          2504                          2505
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2385                             1                             2                          2385                          2386                          2505                          2506
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2386                             1                             2                          2386                          2387                          2506                          2507
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2387                             1                             2                          2387                          2388                          2507                          2508
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2388                             1                             2                          2388                          2389                          2508                          2509
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2389                             1                             2                          2389                          2390                          2509                          2510
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2390                             1                             2                          2390                          2391                          2510                          2511
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2391                             1                             2                          2391                          2392                          2511                          2512
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2392                             1                             2                          2392                          2393                          2512                          2513
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2393                             1                             2                          2393                          2394                          2513                          2514
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2394                             1                             2                          2394                          2395                          2514                          2515
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2395                             1                             2                          2395                          2396                          2515                          2516
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2396                             1                             2                          2396                          2397                          2516                          2517
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2397                             1                             2                          2397                          2398                          2517                          2518
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2398                             1                             2                          2398                          2399                          2518                          2519
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2399                             1                             2                          2399                          2400                          2519                          2520
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2400                             1                             2                          2400                          2281                          2520                          2401
  0.2179339429544461387289E-01  0.2375860202875963028690E-01
                          2401                             1                             2                          2401                          2402                          2521                          2522
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2402                             1                             2                          2402                          2403                          2522                          2523
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2403                             1                             2                          2403                          2404                          2523                          2524
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2404                             1                             2                          2404                          2405                          2524                          2525
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2405                             1                             2                          2405                          2406                          2525                          2526
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2406                             1                             2                          2406                          2407                          2526                          2527
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2407                             1                             2                          2407                          2408                          2527                          2528
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2408                             1                             2                          2408                          2409                          2528                          2529
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2409                             1                             2                          2409                          2410                          2529                          2530
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2410                             1                             2                          2410                          2411                          2530                          2531
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2411                             1                             2                          2411                          2412                          2531                          2532
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2412                             1                             2                          2412                          2413                          2532                          2533
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2413                             1                             2                          2413                          2414                          2533                          2534
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2414                             1                             2                          2414                          2415                          2534                          2535
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2415                             1                             2                          2415                          2416                          2535                          2536
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2416                             1                             2                          2416                          2417                          2536                          2537
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2417                             1                             2                          2417                          2418                          2537                          2538
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2418                             1                             2                          2418                          2419                          2538                          2539
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2419                             1                             2                          2419                          2420                          2539                          2540
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2420                             1                             2                          2420                          2421                          2540                          2541
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2421                             1                             2                          2421                          2422                          2541                          2542
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2422                             1                             2                          2422                          2423                          2542                          2543
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2423                             1                             2                          2423                          2424                          2543                          2544
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2424                             1                             2                          2424                          2425                          2544                          2545
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2425                             1                             2                          2425                          2426                          2545                          2546
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2426                             1                             2                          2426                          2427                          2546                          2547
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2427                             1                             2                          2427                          2428                          2547                          2548
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2428                             1                             2                          2428                          2429                          2548                          2549
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2429                             1                             2                          2429                          2430                          2549                          2550
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2430                             1                             2                          2430                          2431                          2550                          2551
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2431                             1                             2                          2431                          2432                          2551                          2552
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2432                             1                             2                          2432                          2433                          2552                          2553
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2433                             1                             2                          2433                          2434                          2553                          2554
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2434                             1                             2                          2434                          2435                          2554                          2555
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2435                             1                             2                          2435                          2436                          2555                          2556
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2436                             1                             2                          2436                          2437                          2556                          2557
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2437                             1                             2                          2437                          2438                          2557                          2558
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2438                             1                             2                          2438                          2439                          2558                          2559
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2439                             1                             2                          2439                          2440                          2559                          2560
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2440                             1                             2                          2440                          2441                          2560                          2561
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2441                             1                             2                          2441                          2442                          2561                          2562
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2442                             1                             2                          2442                          2443                          2562                          2563
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2443                             1                             2                          2443                          2444                          2563                          2564
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2444                             1                             2                          2444                          2445                          2564                          2565
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2445                             1                             2                          2445                          2446                          2565                          2566
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2446                             1                             2                          2446                          2447                          2566                          2567
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2447                             1                             2                          2447                          2448                          2567                          2568
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2448                             1                             2                          2448                          2449                          2568                          2569
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2449                             1                             2                          2449                          2450                          2569                          2570
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2450                             1                             2                          2450                          2451                          2570                          2571
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2451                             1                             2                          2451                          2452                          2571                          2572
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2452                             1                             2                          2452                          2453                          2572                          2573
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2453                             1                             2                          2453                          2454                          2573                          2574
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2454                             1                             2                          2454                          2455                          2574                          2575
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2455                             1                             2                          2455                          2456                          2575                          2576
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2456                             1                             2                          2456                          2457                          2576                          2577
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2457                             1                             2                          2457                          2458                          2577                          2578
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2458                             1                             2                          2458                          2459                          2578                          2579
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2459                             1                             2                          2459                          2460                          2579                          2580
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2460                             1                             2                          2460                          2461                          2580                          2581
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2461                             1                             2                          2461                          2462                          2581                          2582
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2462                             1                             2                          2462                          2463                          2582                          2583
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2463                             1                             2                          2463                          2464                          2583                          2584
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2464                             1                             2                          2464                          2465                          2584                          2585
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2465                             1                             2                          2465                          2466                          2585                          2586
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2466                             1                             2                          2466                          2467                          2586                          2587
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2467                             1                             2                          2467                          2468                          2587                          2588
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2468                             1                             2                          2468                          2469                          2588                          2589
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2469                             1                             2                          2469                          2470                          2589                          2590
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2470                             1                             2                          2470                          2471                          2590                          2591
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2471                             1                             2                          2471                          2472                          2591                          2592
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2472                             1                             2                          2472                          2473                          2592                          2593
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2473                             1                             2                          2473                          2474                          2593                          2594
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2474                             1                             2                          2474                          2475                          2594                          2595
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2475                             1                             2                          2475                          2476                          2595                          2596
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2476                             1                             2                          2476                          2477                          2596                          2597
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2477                             1                             2                          2477                          2478                          2597                          2598
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2478                             1                             2                          2478                          2479                          2598                          2599
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2479                             1                             2                          2479                          2480                          2599                          2600
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2480                             1                             2                          2480                          2481                          2600                          2601
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2481                             1                             2                          2481                          2482                          2601                          2602
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2482                             1                             2                          2482                          2483                          2602                          2603
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2483                             1                             2                          2483                          2484                          2603                          2604
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2484                             1                             2                          2484                          2485                          2604                          2605
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2485                             1                             2                          2485                          2486                          2605                          2606
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2486                             1                             2                          2486                          2487                          2606                          2607
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2487                             1                             2                          2487                          2488                          2607                          2608
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2488                             1                             2                          2488                          2489                          2608                          2609
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2489                             1                             2                          2489                          2490                          2609                          2610
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2490                             1                             2                          2490                          2491                          2610                          2611
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2491                             1                             2                          2491                          2492                          2611                          2612
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2492                             1                             2                          2492                          2493                          2612                          2613
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2493                             1                             2                          2493                          2494                          2613                          2614
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2494                             1                             2                          2494                          2495                          2614                          2615
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2495                             1                             2                          2495                          2496                          2615                          2616
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2496                             1                             2                          2496                          2497                          2616                          2617
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2497                             1                             2                          2497                          2498                          2617                          2618
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2498                             1                             2                          2498                          2499                          2618                          2619
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2499                             1                             2                          2499                          2500                          2619                          2620
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2500                             1                             2                          2500                          2501                          2620                          2621
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2501                             1                             2                          2501                          2502                          2621                          2622
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2502                             1                             2                          2502                          2503                          2622                          2623
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2503                             1                             2                          2503                          2504                          2623                          2624
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2504                             1                             2                          2504                          2505                          2624                          2625
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2505                             1                             2                          2505                          2506                          2625                          2626
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2506                             1                             2                          2506                          2507                          2626                          2627
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2507                             1                             2                          2507                          2508                          2627                          2628
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2508                             1                             2                          2508                          2509                          2628                          2629
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2509                             1                             2                          2509                          2510                          2629                          2630
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2510                             1                             2                          2510                          2511                          2630                          2631
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2511                             1                             2                          2511                          2512                          2631                          2632
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2512                             1                             2                          2512                          2513                          2632                          2633
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2513                             1                             2                          2513                          2514                          2633                          2634
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2514                             1                             2                          2514                          2515                          2634                          2635
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2515                             1                             2                          2515                          2516                          2635                          2636
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2516                             1                             2                          2516                          2517                          2636                          2637
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2517                             1                             2                          2517                          2518                          2637                          2638
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2518                             1                             2                          2518                          2519                          2638                          2639
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2519                             1                             2                          2519                          2520                          2639                          2640
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2520                             1                             2                          2520                          2401                          2640                          2521
  0.2029307227154060477847E-01  0.3467957746560013099213E-01
                          2521                             1                             2                          2521                          2522                          2641                          2642
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2522                             1                             2                          2522                          2523                          2642                          2643
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2523                             1                             2                          2523                          2524                          2643                          2644
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2524                             1                             2                          2524                          2525                          2644                          2645
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2525                             1                             2                          2525                          2526                          2645                          2646
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2526                             1                             2                          2526                          2527                          2646                          2647
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2527                             1                             2                          2527                          2528                          2647                          2648
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2528                             1                             2                          2528                          2529                          2648                          2649
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2529                             1                             2                          2529                          2530                          2649                          2650
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2530                             1                             2                          2530                          2531                          2650                          2651
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2531                             1                             2                          2531                          2532                          2651                          2652
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2532                             1                             2                          2532                          2533                          2652                          2653
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2533                             1                             2                          2533                          2534                          2653                          2654
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2534                             1                             2                          2534                          2535                          2654                          2655
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2535                             1                             2                          2535                          2536                          2655                          2656
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2536                             1                             2                          2536                          2537                          2656                          2657
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2537                             1                             2                          2537                          2538                          2657                          2658
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2538                             1                             2                          2538                          2539                          2658                          2659
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2539                             1                             2                          2539                          2540                          2659                          2660
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2540                             1                             2                          2540                          2541                          2660                          2661
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2541                             1                             2                          2541                          2542                          2661                          2662
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2542                             1                             2                          2542                          2543                          2662                          2663
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2543                             1                             2                          2543                          2544                          2663                          2664
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2544                             1                             2                          2544                          2545                          2664                          2665
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2545                             1                             2                          2545                          2546                          2665                          2666
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2546                             1                             2                          2546                          2547                          2666                          2667
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2547                             1                             2                          2547                          2548                          2667                          2668
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2548                             1                             2                          2548                          2549                          2668                          2669
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2549                             1                             2                          2549                          2550                          2669                          2670
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2550                             1                             2                          2550                          2551                          2670                          2671
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2551                             1                             2                          2551                          2552                          2671                          2672
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2552                             1                             2                          2552                          2553                          2672                          2673
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2553                             1                             2                          2553                          2554                          2673                          2674
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2554                             1                             2                          2554                          2555                          2674                          2675
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2555                             1                             2                          2555                          2556                          2675                          2676
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2556                             1                             2                          2556                          2557                          2676                          2677
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2557                             1                             2                          2557                          2558                          2677                          2678
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2558                             1                             2                          2558                          2559                          2678                          2679
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2559                             1                             2                          2559                          2560                          2679                          2680
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2560                             1                             2                          2560                          2561                          2680                          2681
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2561                             1                             2                          2561                          2562                          2681                          2682
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2562                             1                             2                          2562                          2563                          2682                          2683
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2563                             1                             2                          2563                          2564                          2683                          2684
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2564                             1                             2                          2564                          2565                          2684                          2685
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2565                             1                             2                          2565                          2566                          2685                          2686
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2566                             1                             2                          2566                          2567                          2686                          2687
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2567                             1                             2                          2567                          2568                          2687                          2688
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2568                             1                             2                          2568                          2569                          2688                          2689
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
                          2569                             1                             2                          2569                          2570                          2689                          2690
  0.1850222070588906919664E-01  0.3547265021575876642324E-01
