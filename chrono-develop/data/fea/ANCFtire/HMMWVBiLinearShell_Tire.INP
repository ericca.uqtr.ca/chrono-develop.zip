                           735                             1                             3                           735                           736                           855                           856
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           736                             1                             3                           736                           737                           856                           857
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           737                             1                             3                           737                           738                           857                           858
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           738                             1                             3                           738                           739                           858                           859
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           739                             1                             3                           739                           740                           859                           860
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           740                             1                             3                           740                           741                           860                           861
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           741                             1                             3                           741                           742                           861                           862
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           742                             1                             3                           742                           743                           862                           863
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           743                             1                             3                           743                           744                           863                           864
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           744                             1                             3                           744                           745                           864                           865
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           745                             1                             3                           745                           746                           865                           866
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           746                             1                             3                           746                           747                           866                           867
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           747                             1                             3                           747                           748                           867                           868
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           748                             1                             3                           748                           749                           868                           869
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           749                             1                             3                           749                           750                           869                           870
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           750                             1                             3                           750                           751                           870                           871
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           751                             1                             3                           751                           752                           871                           872
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           752                             1                             3                           752                           753                           872                           873
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           753                             1                             3                           753                           754                           873                           874
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           754                             1                             3                           754                           755                           874                           875
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           755                             1                             3                           755                           756                           875                           876
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           756                             1                             3                           756                           757                           876                           877
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           757                             1                             3                           757                           758                           877                           878
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           758                             1                             3                           758                           759                           878                           879
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           759                             1                             3                           759                           760                           879                           880
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           760                             1                             3                           760                           761                           880                           881
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           761                             1                             3                           761                           762                           881                           882
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           762                             1                             3                           762                           763                           882                           883
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           763                             1                             3                           763                           764                           883                           884
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           764                             1                             3                           764                           765                           884                           885
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           765                             1                             3                           765                           766                           885                           886
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           766                             1                             3                           766                           767                           886                           887
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           767                             1                             3                           767                           768                           887                           888
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           768                             1                             3                           768                           769                           888                           889
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           769                             1                             3                           769                           770                           889                           890
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           770                             1                             3                           770                           771                           890                           891
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           771                             1                             3                           771                           772                           891                           892
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           772                             1                             3                           772                           773                           892                           893
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           773                             1                             3                           773                           774                           893                           894
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           774                             1                             3                           774                           775                           894                           895
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           775                             1                             3                           775                           776                           895                           896
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           776                             1                             3                           776                           777                           896                           897
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           777                             1                             3                           777                           778                           897                           898
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           778                             1                             3                           778                           779                           898                           899
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           779                             1                             3                           779                           780                           899                           900
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           780                             1                             3                           780                           781                           900                           901
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           781                             1                             3                           781                           782                           901                           902
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           782                             1                             3                           782                           783                           902                           903
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           783                             1                             3                           783                           784                           903                           904
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           784                             1                             3                           784                           785                           904                           905
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           785                             1                             3                           785                           786                           905                           906
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           786                             1                             3                           786                           787                           906                           907
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           787                             1                             3                           787                           788                           907                           908
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           788                             1                             3                           788                           789                           908                           909
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           789                             1                             3                           789                           790                           909                           910
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           790                             1                             3                           790                           791                           910                           911
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           791                             1                             3                           791                           792                           911                           912
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           792                             1                             3                           792                           793                           912                           913
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           793                             1                             3                           793                           794                           913                           914
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           794                             1                             3                           794                           795                           914                           915
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           795                             1                             3                           795                           796                           915                           916
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           796                             1                             3                           796                           797                           916                           917
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           797                             1                             3                           797                           798                           917                           918
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           798                             1                             3                           798                           799                           918                           919
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           799                             1                             3                           799                           800                           919                           920
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           800                             1                             3                           800                           801                           920                           921
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           801                             1                             3                           801                           802                           921                           922
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           802                             1                             3                           802                           803                           922                           923
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           803                             1                             3                           803                           804                           923                           924
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           804                             1                             3                           804                           805                           924                           925
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           805                             1                             3                           805                           806                           925                           926
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           806                             1                             3                           806                           807                           926                           927
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           807                             1                             3                           807                           808                           927                           928
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           808                             1                             3                           808                           809                           928                           929
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           809                             1                             3                           809                           810                           929                           930
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           810                             1                             3                           810                           811                           930                           931
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           811                             1                             3                           811                           812                           931                           932
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           812                             1                             3                           812                           813                           932                           933
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           813                             1                             3                           813                           814                           933                           934
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           814                             1                             3                           814                           815                           934                           935
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           815                             1                             3                           815                           816                           935                           936
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           816                             1                             3                           816                           817                           936                           937
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           817                             1                             3                           817                           818                           937                           938
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           818                             1                             3                           818                           819                           938                           939
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           819                             1                             3                           819                           820                           939                           940
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           820                             1                             3                           820                           821                           940                           941
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           821                             1                             3                           821                           822                           941                           942
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           822                             1                             3                           822                           823                           942                           943
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           823                             1                             3                           823                           824                           943                           944
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           824                             1                             3                           824                           825                           944                           945
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           825                             1                             3                           825                           826                           945                           946
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           826                             1                             3                           826                           827                           946                           947
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           827                             1                             3                           827                           828                           947                           948
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           828                             1                             3                           828                           829                           948                           949
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           829                             1                             3                           829                           830                           949                           950
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           830                             1                             3                           830                           831                           950                           951
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           831                             1                             3                           831                           832                           951                           952
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           832                             1                             3                           832                           833                           952                           953
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           833                             1                             3                           833                           834                           953                           954
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           834                             1                             3                           834                           835                           954                           955
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           835                             1                             3                           835                           836                           955                           956
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           836                             1                             3                           836                           837                           956                           957
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           837                             1                             3                           837                           838                           957                           958
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           838                             1                             3                           838                           839                           958                           959
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           839                             1                             3                           839                           840                           959                           960
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           840                             1                             3                           840                           721                           960                           841
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           841                             1                             3                           841                           842                           961                           962
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           842                             1                             3                           842                           843                           962                           963
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           843                             1                             3                           843                           844                           963                           964
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           844                             1                             3                           844                           845                           964                           965
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           845                             1                             3                           845                           846                           965                           966
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           846                             1                             3                           846                           847                           966                           967
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           847                             1                             3                           847                           848                           967                           968
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           848                             1                             3                           848                           849                           968                           969
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           849                             1                             3                           849                           850                           969                           970
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           850                             1                             3                           850                           851                           970                           971
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           851                             1                             3                           851                           852                           971                           972
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           852                             1                             3                           852                           853                           972                           973
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           853                             1                             3                           853                           854                           973                           974
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           854                             1                             3                           854                           855                           974                           975
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           855                             1                             3                           855                           856                           975                           976
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           856                             1                             3                           856                           857                           976                           977
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           857                             1                             3                           857                           858                           977                           978
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           858                             1                             3                           858                           859                           978                           979
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           859                             1                             3                           859                           860                           979                           980
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           860                             1                             3                           860                           861                           980                           981
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           861                             1                             3                           861                           862                           981                           982
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           862                             1                             3                           862                           863                           982                           983
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           863                             1                             3                           863                           864                           983                           984
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           864                             1                             3                           864                           865                           984                           985
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           865                             1                             3                           865                           866                           985                           986
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           866                             1                             3                           866                           867                           986                           987
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           867                             1                             3                           867                           868                           987                           988
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           868                             1                             3                           868                           869                           988                           989
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           869                             1                             3                           869                           870                           989                           990
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           870                             1                             3                           870                           871                           990                           991
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           871                             1                             3                           871                           872                           991                           992
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           872                             1                             3                           872                           873                           992                           993
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           873                             1                             3                           873                           874                           993                           994
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           874                             1                             3                           874                           875                           994                           995
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           875                             1                             3                           875                           876                           995                           996
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           876                             1                             3                           876                           877                           996                           997
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           877                             1                             3                           877                           878                           997                           998
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           878                             1                             3                           878                           879                           998                           999
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           879                             1                             3                           879                           880                           999                          1000
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           880                             1                             3                           880                           881                          1000                          1001
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           881                             1                             3                           881                           882                          1001                          1002
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           882                             1                             3                           882                           883                          1002                          1003
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           883                             1                             3                           883                           884                          1003                          1004
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           884                             1                             3                           884                           885                          1004                          1005
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           885                             1                             3                           885                           886                          1005                          1006
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           886                             1                             3                           886                           887                          1006                          1007
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           887                             1                             3                           887                           888                          1007                          1008
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           888                             1                             3                           888                           889                          1008                          1009
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           889                             1                             3                           889                           890                          1009                          1010
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           890                             1                             3                           890                           891                          1010                          1011
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           891                             1                             3                           891                           892                          1011                          1012
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           892                             1                             3                           892                           893                          1012                          1013
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           893                             1                             3                           893                           894                          1013                          1014
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           894                             1                             3                           894                           895                          1014                          1015
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           895                             1                             3                           895                           896                          1015                          1016
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           896                             1                             3                           896                           897                          1016                          1017
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           897                             1                             3                           897                           898                          1017                          1018
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           898                             1                             3                           898                           899                          1018                          1019
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           899                             1                             3                           899                           900                          1019                          1020
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           900                             1                             3                           900                           901                          1020                          1021
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           901                             1                             3                           901                           902                          1021                          1022
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           902                             1                             3                           902                           903                          1022                          1023
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           903                             1                             3                           903                           904                          1023                          1024
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           904                             1                             3                           904                           905                          1024                          1025
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           905                             1                             3                           905                           906                          1025                          1026
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           906                             1                             3                           906                           907                          1026                          1027
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           907                             1                             3                           907                           908                          1027                          1028
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           908                             1                             3                           908                           909                          1028                          1029
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           909                             1                             3                           909                           910                          1029                          1030
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           910                             1                             3                           910                           911                          1030                          1031
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           911                             1                             3                           911                           912                          1031                          1032
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           912                             1                             3                           912                           913                          1032                          1033
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           913                             1                             3                           913                           914                          1033                          1034
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           914                             1                             3                           914                           915                          1034                          1035
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           915                             1                             3                           915                           916                          1035                          1036
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           916                             1                             3                           916                           917                          1036                          1037
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           917                             1                             3                           917                           918                          1037                          1038
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           918                             1                             3                           918                           919                          1038                          1039
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           919                             1                             3                           919                           920                          1039                          1040
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           920                             1                             3                           920                           921                          1040                          1041
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           921                             1                             3                           921                           922                          1041                          1042
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           922                             1                             3                           922                           923                          1042                          1043
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           923                             1                             3                           923                           924                          1043                          1044
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           924                             1                             3                           924                           925                          1044                          1045
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           925                             1                             3                           925                           926                          1045                          1046
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           926                             1                             3                           926                           927                          1046                          1047
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           927                             1                             3                           927                           928                          1047                          1048
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           928                             1                             3                           928                           929                          1048                          1049
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           929                             1                             3                           929                           930                          1049                          1050
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           930                             1                             3                           930                           931                          1050                          1051
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           931                             1                             3                           931                           932                          1051                          1052
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           932                             1                             3                           932                           933                          1052                          1053
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           933                             1                             3                           933                           934                          1053                          1054
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           934                             1                             3                           934                           935                          1054                          1055
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           935                             1                             3                           935                           936                          1055                          1056
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           936                             1                             3                           936                           937                          1056                          1057
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           937                             1                             3                           937                           938                          1057                          1058
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           938                             1                             3                           938                           939                          1058                          1059
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           939                             1                             3                           939                           940                          1059                          1060
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           940                             1                             3                           940                           941                          1060                          1061
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           941                             1                             3                           941                           942                          1061                          1062
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           942                             1                             3                           942                           943                          1062                          1063
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           943                             1                             3                           943                           944                          1063                          1064
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           944                             1                             3                           944                           945                          1064                          1065
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           945                             1                             3                           945                           946                          1065                          1066
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           946                             1                             3                           946                           947                          1066                          1067
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           947                             1                             3                           947                           948                          1067                          1068
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           948                             1                             3                           948                           949                          1068                          1069
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           949                             1                             3                           949                           950                          1069                          1070
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           950                             1                             3                           950                           951                          1070                          1071
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           951                             1                             3                           951                           952                          1071                          1072
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           952                             1                             3                           952                           953                          1072                          1073
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           953                             1                             3                           953                           954                          1073                          1074
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           954                             1                             3                           954                           955                          1074                          1075
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           955                             1                             3                           955                           956                          1075                          1076
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           956                             1                             3                           956                           957                          1076                          1077
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           957                             1                             3                           957                           958                          1077                          1078
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           958                             1                             3                           958                           959                          1078                          1079
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           959                             1                             3                           959                           960                          1079                          1080
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           960                             1                             3                           960                           841                          1080                           961
  0.2430857769130332496355E-01  0.2130598452915481721970E-01
                           961                             1                             3                           961                           962                          1081                          1082
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           962                             1                             3                           962                           963                          1082                          1083
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           963                             1                             3                           963                           964                          1083                          1084
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           964                             1                             3                           964                           965                          1084                          1085
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           965                             1                             3                           965                           966                          1085                          1086
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           966                             1                             3                           966                           967                          1086                          1087
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           967                             1                             3                           967                           968                          1087                          1088
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           968                             1                             3                           968                           969                          1088                          1089
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           969                             1                             3                           969                           970                          1089                          1090
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           970                             1                             3                           970                           971                          1090                          1091
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           971                             1                             3                           971                           972                          1091                          1092
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           972                             1                             3                           972                           973                          1092                          1093
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           973                             1                             3                           973                           974                          1093                          1094
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           974                             1                             3                           974                           975                          1094                          1095
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           975                             1                             3                           975                           976                          1095                          1096
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           976                             1                             3                           976                           977                          1096                          1097
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           977                             1                             3                           977                           978                          1097                          1098
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           978                             1                             3                           978                           979                          1098                          1099
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           979                             1                             3                           979                           980                          1099                          1100
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           980                             1                             3                           980                           981                          1100                          1101
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           981                             1                             3                           981                           982                          1101                          1102
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           982                             1                             3                           982                           983                          1102                          1103
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           983                             1                             3                           983                           984                          1103                          1104
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           984                             1                             3                           984                           985                          1104                          1105
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           985                             1                             3                           985                           986                          1105                          1106
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           986                             1                             3                           986                           987                          1106                          1107
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           987                             1                             3                           987                           988                          1107                          1108
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           988                             1                             3                           988                           989                          1108                          1109
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           989                             1                             3                           989                           990                          1109                          1110
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           990                             1                             3                           990                           991                          1110                          1111
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           991                             1                             3                           991                           992                          1111                          1112
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           992                             1                             3                           992                           993                          1112                          1113
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           993                             1                             3                           993                           994                          1113                          1114
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           994                             1                             3                           994                           995                          1114                          1115
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           995                             1                             3                           995                           996                          1115                          1116
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           996                             1                             3                           996                           997                          1116                          1117
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           997                             1                             3                           997                           998                          1117                          1118
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           998                             1                             3                           998                           999                          1118                          1119
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                           999                             1                             3                           999                          1000                          1119                          1120
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1000                             1                             3                          1000                          1001                          1120                          1121
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1001                             1                             3                          1001                          1002                          1121                          1122
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1002                             1                             3                          1002                          1003                          1122                          1123
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1003                             1                             3                          1003                          1004                          1123                          1124
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1004                             1                             3                          1004                          1005                          1124                          1125
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1005                             1                             3                          1005                          1006                          1125                          1126
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1006                             1                             3                          1006                          1007                          1126                          1127
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1007                             1                             3                          1007                          1008                          1127                          1128
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1008                             1                             3                          1008                          1009                          1128                          1129
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1009                             1                             3                          1009                          1010                          1129                          1130
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1010                             1                             3                          1010                          1011                          1130                          1131
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1011                             1                             3                          1011                          1012                          1131                          1132
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1012                             1                             3                          1012                          1013                          1132                          1133
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1013                             1                             3                          1013                          1014                          1133                          1134
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1014                             1                             3                          1014                          1015                          1134                          1135
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1015                             1                             3                          1015                          1016                          1135                          1136
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1016                             1                             3                          1016                          1017                          1136                          1137
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1017                             1                             3                          1017                          1018                          1137                          1138
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1018                             1                             3                          1018                          1019                          1138                          1139
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1019                             1                             3                          1019                          1020                          1139                          1140
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1020                             1                             3                          1020                          1021                          1140                          1141
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1021                             1                             3                          1021                          1022                          1141                          1142
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1022                             1                             3                          1022                          1023                          1142                          1143
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1023                             1                             3                          1023                          1024                          1143                          1144
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1024                             1                             3                          1024                          1025                          1144                          1145
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1025                             1                             3                          1025                          1026                          1145                          1146
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1026                             1                             3                          1026                          1027                          1146                          1147
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1027                             1                             3                          1027                          1028                          1147                          1148
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1028                             1                             3                          1028                          1029                          1148                          1149
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1029                             1                             3                          1029                          1030                          1149                          1150
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1030                             1                             3                          1030                          1031                          1150                          1151
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1031                             1                             3                          1031                          1032                          1151                          1152
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1032                             1                             3                          1032                          1033                          1152                          1153
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1033                             1                             3                          1033                          1034                          1153                          1154
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1034                             1                             3                          1034                          1035                          1154                          1155
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1035                             1                             3                          1035                          1036                          1155                          1156
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1036                             1                             3                          1036                          1037                          1156                          1157
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1037                             1                             3                          1037                          1038                          1157                          1158
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1038                             1                             3                          1038                          1039                          1158                          1159
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1039                             1                             3                          1039                          1040                          1159                          1160
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1040                             1                             3                          1040                          1041                          1160                          1161
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1041                             1                             3                          1041                          1042                          1161                          1162
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1042                             1                             3                          1042                          1043                          1162                          1163
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1043                             1                             3                          1043                          1044                          1163                          1164
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1044                             1                             3                          1044                          1045                          1164                          1165
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1045                             1                             3                          1045                          1046                          1165                          1166
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1046                             1                             3                          1046                          1047                          1166                          1167
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1047                             1                             3                          1047                          1048                          1167                          1168
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1048                             1                             3                          1048                          1049                          1168                          1169
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1049                             1                             3                          1049                          1050                          1169                          1170
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1050                             1                             3                          1050                          1051                          1170                          1171
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1051                             1                             3                          1051                          1052                          1171                          1172
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1052                             1                             3                          1052                          1053                          1172                          1173
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1053                             1                             3                          1053                          1054                          1173                          1174
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1054                             1                             3                          1054                          1055                          1174                          1175
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1055                             1                             3                          1055                          1056                          1175                          1176
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1056                             1                             3                          1056                          1057                          1176                          1177
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1057                             1                             3                          1057                          1058                          1177                          1178
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1058                             1                             3                          1058                          1059                          1178                          1179
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1059                             1                             3                          1059                          1060                          1179                          1180
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1060                             1                             3                          1060                          1061                          1180                          1181
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1061                             1                             3                          1061                          1062                          1181                          1182
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1062                             1                             3                          1062                          1063                          1182                          1183
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1063                             1                             3                          1063                          1064                          1183                          1184
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1064                             1                             3                          1064                          1065                          1184                          1185
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1065                             1                             3                          1065                          1066                          1185                          1186
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1066                             1                             3                          1066                          1067                          1186                          1187
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1067                             1                             3                          1067                          1068                          1187                          1188
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1068                             1                             3                          1068                          1069                          1188                          1189
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1069                             1                             3                          1069                          1070                          1189                          1190
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1070                             1                             3                          1070                          1071                          1190                          1191
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1071                             1                             3                          1071                          1072                          1191                          1192
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1072                             1                             3                          1072                          1073                          1192                          1193
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1073                             1                             3                          1073                          1074                          1193                          1194
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1074                             1                             3                          1074                          1075                          1194                          1195
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1075                             1                             3                          1075                          1076                          1195                          1196
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1076                             1                             3                          1076                          1077                          1196                          1197
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1077                             1                             3                          1077                          1078                          1197                          1198
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1078                             1                             3                          1078                          1079                          1198                          1199
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1079                             1                             3                          1079                          1080                          1199                          1200
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1080                             1                             3                          1080                           961                          1200                          1081
  0.2442593239710638686191E-01  0.2087836460363725124556E-01
                          1081                             1                             3                          1081                          1082                          1201                          1202
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1082                             1                             3                          1082                          1083                          1202                          1203
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1083                             1                             3                          1083                          1084                          1203                          1204
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1084                             1                             3                          1084                          1085                          1204                          1205
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1085                             1                             3                          1085                          1086                          1205                          1206
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1086                             1                             3                          1086                          1087                          1206                          1207
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1087                             1                             3                          1087                          1088                          1207                          1208
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1088                             1                             3                          1088                          1089                          1208                          1209
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1089                             1                             3                          1089                          1090                          1209                          1210
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1090                             1                             3                          1090                          1091                          1210                          1211
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1091                             1                             3                          1091                          1092                          1211                          1212
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1092                             1                             3                          1092                          1093                          1212                          1213
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1093                             1                             3                          1093                          1094                          1213                          1214
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1094                             1                             3                          1094                          1095                          1214                          1215
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1095                             1                             3                          1095                          1096                          1215                          1216
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1096                             1                             3                          1096                          1097                          1216                          1217
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1097                             1                             3                          1097                          1098                          1217                          1218
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1098                             1                             3                          1098                          1099                          1218                          1219
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1099                             1                             3                          1099                          1100                          1219                          1220
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1100                             1                             3                          1100                          1101                          1220                          1221
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
                          1101                             1                             3                          1101                          1102                          1221                          1222
  0.2443786450795362719113E-01  0.2087844553861295179842E-01
