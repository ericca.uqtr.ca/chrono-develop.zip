  0.4435588543010565154567E+00  0.8350873084007624791436E-01  0.3231789917990847693652E+00 -0.9496078499693529906267E+00 -0.5517350488583696449529E-01  0.3085462941524254598669E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1946                             0                             0                             0                             0                             0                             0
  0.4504936830858279894763E+00  0.8350873084007624791436E-01  0.3465905814218303016006E+00 -0.9644545107638700098818E+00 -0.5517350488583697143419E-01  0.2584248072957324171561E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1947                             0                             0                             0                             0                             0                             0
  0.4561937399986931152007E+00  0.8350873084007624791436E-01  0.3703330271704898257745E+00 -0.9766576687827943636933E+00 -0.5517350488583697143419E-01  0.2075949960051299003627E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1948                             0                             0                             0                             0                             0                             0
  0.4606434015798599457270E+00  0.8350873084007624791436E-01  0.3943412526515832627894E+00 -0.9861838760182272123345E+00 -0.5517350488583697837308E-01  0.1561961812602288002250E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1949                             0                             0                             0                             0                             0                             0
  0.4638304716162265362023E+00  0.8350873084007624791436E-01  0.4185494529878585057148E+00 -0.9930070217982948088675E+00 -0.5517350488583696449529E-01  0.1043692436395566164320E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1950                             0                             0                             0                             0                             0                             0
  0.4657462145703539224684E+00  0.8350873084007624791436E-01  0.4428912751848850248848E+00 -0.9971084043546851738427E+00 -0.5517350488583696449529E-01  0.5225623717668559375937E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1951                             0                             0                             0                             0                             0                             0
  0.4663853795239664146166E+00  0.8350873084007624791436E-01  0.4672999999999998821387E+00 -0.9984767820828946982559E+00 -0.5517350488583697143419E-01  0.2217063826044129322703E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1952                             0                             0                             0                             0                             0                             0
  0.4657462145703539224684E+00  0.8350873084007624791436E-01  0.4917087248151149614372E+00 -0.9971084043546851738427E+00 -0.5517350488583696449529E-01 -0.5225623717668559375937E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1953                             0                             0                             0                             0                             0                             0
  0.4638304716162265362023E+00  0.8350873084007624791436E-01  0.5160505470121414806073E+00 -0.9930070217982948088675E+00 -0.5517350488583696449529E-01 -0.1043692436395566164320E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1954                             0                             0                             0                             0                             0                             0
  0.4606434015798599457270E+00  0.8350873084007624791436E-01  0.5402587473484167235327E+00 -0.9861838760182272123345E+00 -0.5517350488583697837308E-01 -0.1561961812602288002250E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1955                             0                             0                             0                             0                             0                             0
  0.4561937399986930596896E+00  0.8350873084007624791436E-01  0.5642669728295102160587E+00 -0.9766576687827942526710E+00 -0.5517350488583696449529E-01 -0.2075949960051301224073E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1956                             0                             0                             0                             0                             0                             0
  0.4504936830858279894763E+00  0.8350873084007624791436E-01  0.5880094185781696847215E+00 -0.9644545107638700098818E+00 -0.5517350488583697143419E-01 -0.2584248072957324171561E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1957                             0                             0                             0                             0                             0                             0
  0.4435588543010565154567E+00  0.8350873084007624791436E-01  0.6114210082009152724680E+00 -0.9496078499693529906267E+00 -0.5517350488583696449529E-01 -0.3085462941524254598669E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1958                             0                             0                             0                             0                             0                             0
  0.4354082615280438495198E+00  0.8350873084007624791436E-01  0.6344375721579105231740E+00 -0.9321583800645023565323E+00 -0.5517350488583697143419E-01 -0.3578220770636366121487E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1959                             0                             0                             0                             0                             0                             0
  0.4260642449750400295727E+00  0.8350873084007624791436E-01  0.6569960236472111025918E+00 -0.9121539288334296058380E+00 -0.5517350488583697143419E-01 -0.4061170945335238480212E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1960                             0                             0                             0                             0                             0                             0
  0.4155524159419221041922E+00  0.8350873084007624791436E-01  0.6790345315213036636592E+00 -0.8896493270864664903996E+00 -0.5517350488583697837308E-01 -0.4532989732761478762768E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1961                             0                             0                             0                             0                             0                             0
  0.4039015866214016869939E+00  0.8350873084007624791436E-01  0.7004926897619830894470E+00 -0.8647062583727258555655E+00 -0.5517350488583697143419E-01 -0.4992383910414471825945E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1962                             0                             0                             0                             0                             0                             0
  0.3911436911268071359160E+00  0.8350873084007624791436E-01  0.7213116830490501341089E+00 -0.8373930899097807856180E+00 -0.5517350488583697143419E-01 -0.5438094310785370755212E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1963                             0                             0                             0                             0                             0                             0
  0.3773136979628984866153E+00  0.8350873084007624791436E-01  0.7414344479690153644214E+00 -0.8077846851938728089948E+00 -0.5517350488583697143419E-01 -0.5868899272647709608464E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1964                             0                             0                             0                             0                             0                             0
  0.3624495141796271746593E+00  0.8350873084007624791436E-01  0.7608058294219492978527E+00 -0.7759621988042737505964E+00 -0.5517350488583697143419E-01 -0.6283617989545904336524E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1965                             0                             0                             0                             0                             0                             0
  0.3465918814715464035814E+00  0.8350873084007624791436E-01  0.7793727317977777735436E+00 -0.7420128539642232290419E+00 -0.5517350488583697143419E-01 -0.6681113746303686262706E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1966                             0                             0                             0                             0                             0                             0
  0.3297842645076582424046E+00  0.8350873084007624791436E-01  0.7970842645076581245434E+00 -0.7060297034681375372145E+00 -0.5517350488583697143419E-01 -0.7060297034681374261922E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1967                             0                             0                             0                             0                             0                             0
  0.3120727317977779469160E+00  0.8350873084007624791436E-01  0.8138918814715462302090E+00 -0.6681113746303689593375E+00 -0.5517350488583697143419E-01 -0.7420128539642228959750E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1968                             0                             0                             0                             0                             0                             0
  0.2935058294219493602029E+00  0.8350873084007624791436E-01  0.8297495141796271678203E+00 -0.6283617989545905446747E+00 -0.5517350488583697143419E-01 -0.7759621988042736395741E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1969                             0                             0                             0                             0                             0                             0
  0.2741344479690154267715E+00  0.8350873084007624791436E-01  0.8446136979628984242652E+00 -0.5868899272647709608464E+00 -0.5517350488583697143419E-01 -0.8077846851938728089948E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1970                             0                             0                             0                             0                             0                             0
  0.2540116830490503074813E+00  0.8350873084007624791436E-01  0.8584436911268069625436E+00 -0.5438094310785374085881E+00 -0.5517350488583697143419E-01 -0.8373930899097805635733E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1971                             0                             0                             0                             0                             0                             0
  0.2331926897619831517972E+00  0.8350873084007624791436E-01  0.8712015866214016801550E+00 -0.4992383910414472381056E+00 -0.5517350488583697143419E-01 -0.8647062583727258555655E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1972                             0                             0                             0                             0                             0                             0
  0.2117345315213036982538E+00  0.8350873084007624791436E-01  0.8828524159419219863310E+00 -0.4532989732761479317880E+00 -0.5517350488583697143419E-01 -0.8896493270864663793773E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1973                             0                             0                             0                             0                             0                             0
  0.1896960236472110539196E+00  0.8350873084007624791436E-01  0.8933642449750400782449E+00 -0.4061170945335236814877E+00 -0.5517350488583697143419E-01 -0.9121539288334296058380E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1974                             0                             0                             0                             0                             0                             0
  0.1671375721579104745018E+00  0.8350873084007624791436E-01  0.9027082615280438426808E+00 -0.3578220770636364456152E+00 -0.5517350488583696449529E-01 -0.9321583800645023565323E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1975                             0                             0                             0                             0                             0                             0
  0.1441210082009152515514E+00  0.8350873084007624791436E-01  0.9108588543010565086178E+00 -0.3085462941524255153780E+00 -0.5517350488583696449529E-01 -0.9496078499693529906267E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1976                             0                             0                             0                             0                             0                             0
  0.1207094185781696082937E+00  0.8350873084007624791436E-01  0.9177936830858279826373E+00 -0.2584248072957322506227E+00 -0.5517350488583696449529E-01 -0.9644545107638700098818E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1977                             0                             0                             0                             0                             0                             0
  0.9696697282951020901987E-01  0.8350873084007624791436E-01  0.9234937399986931083617E+00 -0.2075949960051299558739E+00 -0.5517350488583697143419E-01 -0.9766576687827943636933E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1978                             0                             0                             0                             0                             0                             0
  0.7295874734841675812724E-01  0.8350873084007624791436E-01  0.9279434015798599943992E+00 -0.1561961812602288557361E+00 -0.5517350488583697837308E-01 -0.9861838760182272123345E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1979                             0                             0                             0                             0                             0                             0
  0.4875054701214143887400E-01  0.8350873084007624791436E-01  0.9311304716162265293633E+00 -0.1043692436395564637763E+00 -0.5517350488583697837308E-01 -0.9930070217982949198898E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1980                             0                             0                             0                             0                             0                             0
  0.2440872481511501684848E-01  0.8350873084007624791436E-01  0.9330462145703539711405E+00 -0.5225623717668565620942E-01 -0.5517350488583696449529E-01 -0.9971084043546851738427E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1981                             0                             0                             0                             0                             0                             0
  0.2356745827885772554537E-15  0.8350873084007624791436E-01  0.9336853795239663522665E+00 -0.5045518349688642017611E-15 -0.5517350488583697143419E-01 -0.9984767820828946982559E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1982                             0                             0                             0                             0                             0                             0
 -0.2440872481511495786788E-01  0.8350873084007624791436E-01  0.9330462145703539711405E+00  0.5225623717668553130933E-01 -0.5517350488583696449529E-01 -0.9971084043546851738427E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1983                             0                             0                             0                             0                             0                             0
 -0.4875054701214137642395E-01  0.8350873084007624791436E-01  0.9311304716162265293633E+00  0.1043692436395563388762E+00 -0.5517350488583697143419E-01 -0.9930070217982949198898E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1984                             0                             0                             0                             0                             0                             0
 -0.7295874734841670261609E-01  0.8350873084007624791436E-01  0.9279434015798599943992E+00  0.1561961812602287447138E+00 -0.5517350488583697143419E-01 -0.9861838760182272123345E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1985                             0                             0                             0                             0                             0                             0
 -0.9696697282951015350871E-01  0.8350873084007624791436E-01  0.9234937399986931083617E+00  0.2075949960051298448516E+00 -0.5517350488583697143419E-01 -0.9766576687827943636933E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1986                             0                             0                             0                             0                             0                             0
 -0.1207094185781695666604E+00  0.8350873084007624791436E-01  0.9177936830858279826373E+00  0.2584248072957321396004E+00 -0.5517350488583697143419E-01 -0.9644545107638701209041E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1987                             0                             0                             0                             0                             0                             0
 -0.1441210082009152237958E+00  0.8350873084007624791436E-01  0.9108588543010565086178E+00  0.3085462941524254043557E+00 -0.5517350488583697837308E-01 -0.9496078499693531016490E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1988                             0                             0                             0                             0                             0                             0
 -0.1671375721579104189907E+00  0.8350873084007624791436E-01  0.9027082615280439537031E+00  0.3578220770636363345929E+00 -0.5517350488583697837308E-01 -0.9321583800645024675546E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1989                             0                             0                             0                             0                             0                             0
 -0.1896960236472111649420E+00  0.8350873084007624791436E-01  0.8933642449750399672226E+00  0.4061170945335239590435E+00 -0.5517350488583697143419E-01 -0.9121539288334294948157E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1990                             0                             0                             0                             0                             0                             0
 -0.2117345315213036704982E+00  0.8350873084007624791436E-01  0.8828524159419220973533E+00  0.4532989732761478207657E+00 -0.5517350488583697837308E-01 -0.8896493270864664903996E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1991                             0                             0                             0                             0                             0                             0
 -0.2331926897619830962860E+00  0.8350873084007624791436E-01  0.8712015866214016801550E+00  0.4992383910414471270833E+00 -0.5517350488583696449529E-01 -0.8647062583727258555655E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1992                             0                             0                             0                             0                             0                             0
 -0.2540116830490502519702E+00  0.8350873084007624791436E-01  0.8584436911268069625436E+00  0.5438094310785372975658E+00 -0.5517350488583695755640E-01 -0.8373930899097805635733E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1993                             0                             0                             0                             0                             0                             0
 -0.2741344479690153712603E+00  0.8350873084007624791436E-01  0.8446136979628984242652E+00  0.5868899272647708498241E+00 -0.5517350488583696449529E-01 -0.8077846851938728089948E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1994                             0                             0                             0                             0                             0                             0
 -0.2935058294219493046917E+00  0.8350873084007624791436E-01  0.8297495141796271678203E+00  0.6283617989545904336524E+00 -0.5517350488583697143419E-01 -0.7759621988042737505964E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1995                             0                             0                             0                             0                             0                             0
 -0.3120727317977778914049E+00  0.8350873084007624791436E-01  0.8138918814715463412313E+00  0.6681113746303688483152E+00 -0.5517350488583697143419E-01 -0.7420128539642230069973E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1996                             0                             0                             0                             0                             0                             0
 -0.3297842645076581868935E+00  0.8350873084007624791436E-01  0.7970842645076582355657E+00  0.7060297034681374261922E+00 -0.5517350488583697143419E-01 -0.7060297034681375372145E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1997                             0                             0                             0                             0                             0                             0
 -0.3465918814715461815368E+00  0.8350873084007624791436E-01  0.7793727317977778845659E+00  0.7420128539642227849527E+00 -0.5517350488583695755640E-01 -0.6681113746303689593375E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1998                             0                             0                             0                             0                             0                             0
 -0.3624495141796270636370E+00  0.8350873084007624791436E-01  0.7608058294219495198973E+00  0.7759621988042734175295E+00 -0.5517350488583697143419E-01 -0.6283617989545908777416E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1999                             0                             0                             0                             0                             0                             0
 -0.3773136979628984311042E+00  0.8350873084007624791436E-01  0.7414344479690154754437E+00  0.8077846851938726979725E+00 -0.5517350488583697143419E-01 -0.5868899272647710718687E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2000                             0                             0                             0                             0                             0                             0
 -0.3911436911268071359160E+00  0.8350873084007624791436E-01  0.7213116830490502451312E+00  0.8373930899097807856180E+00 -0.5517350488583697143419E-01 -0.5438094310785371865435E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2001                             0                             0                             0                             0                             0                             0
 -0.4039015866214015759716E+00  0.8350873084007624791436E-01  0.7004926897619834225139E+00  0.8647062583727256335209E+00 -0.5517350488583697143419E-01 -0.4992383910414476821948E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2002                             0                             0                             0                             0                             0                             0
 -0.4155524159419220486811E+00  0.8350873084007624791436E-01  0.6790345315213037746815E+00  0.8896493270864663793773E+00 -0.5517350488583697143419E-01 -0.4532989732761479872991E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2003                             0                             0                             0                             0                             0                             0
 -0.4260642449750398630393E+00  0.8350873084007624791436E-01  0.6569960236472114356587E+00  0.9121539288334292727711E+00 -0.5517350488583697143419E-01 -0.4061170945335245141550E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2004                             0                             0                             0                             0                             0                             0
 -0.4354082615280439605421E+00  0.8350873084007624791436E-01  0.6344375721579103011294E+00  0.9321583800645025785769E+00 -0.5517350488583697143419E-01 -0.3578220770636361125483E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2005                             0                             0                             0                             0                             0                             0
 -0.4435588543010565154567E+00  0.8350873084007624791436E-01  0.6114210082009152724680E+00  0.9496078499693529906267E+00 -0.5517350488583697143419E-01 -0.3085462941524255708892E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2006                             0                             0                             0                             0                             0                             0
 -0.4504936830858279894763E+00  0.8350873084007624791436E-01  0.5880094185781696847215E+00  0.9644545107638700098818E+00 -0.5517350488583696449529E-01 -0.2584248072957323061338E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2007                             0                             0                             0                             0                             0                             0
 -0.4561937399986930596896E+00  0.8350873084007624791436E-01  0.5642669728295104381033E+00  0.9766576687827942526710E+00 -0.5517350488583697143419E-01 -0.2075949960051304554742E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2008                             0                             0                             0                             0                             0                             0
 -0.4606434015798598902158E+00  0.8350873084007624791436E-01  0.5402587473484168345550E+00  0.9861838760182271013122E+00 -0.5517350488583697143419E-01 -0.1561961812602289112473E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2009                             0                             0                             0                             0                             0                             0
 -0.4638304716162265362023E+00  0.8350873084007624791436E-01  0.5160505470121419246965E+00  0.9930070217982948088675E+00 -0.5517350488583697143419E-01 -0.1043692436395574074659E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2010                             0                             0                             0                             0                             0                             0
 -0.4657462145703539779795E+00  0.8350873084007624791436E-01  0.4917087248151148504149E+00  0.9971084043546852848650E+00 -0.5517350488583697143419E-01 -0.5225623717668527457025E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2011                             0                             0                             0                             0                             0                             0
 -0.4663853795239664146166E+00  0.8350873084007624791436E-01  0.4673000000000000486722E+00  0.9984767820828946982559E+00 -0.5517350488583697143419E-01 -0.1222781395200766251372E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2012                             0                             0                             0                             0                             0                             0
 -0.4657462145703539224684E+00  0.8350873084007624791436E-01  0.4428912751848848583514E+00  0.9971084043546851738427E+00 -0.5517350488583696449529E-01  0.5225623717668591294849E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2013                             0                             0                             0                             0                             0                             0
 -0.4638304716162265917134E+00  0.8350873084007624791436E-01  0.4185494529878586167371E+00  0.9930070217982949198898E+00 -0.5517350488583697143419E-01  0.1043692436395562833651E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2014                             0                             0                             0                             0                             0                             0
 -0.4606434015798599457270E+00  0.8350873084007624791436E-01  0.3943412526515833183005E+00  0.9861838760182272123345E+00 -0.5517350488583697143419E-01  0.1561961812602286614471E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2015                             0                             0                             0                             0                             0                             0
 -0.4561937399986930596896E+00  0.8350873084007624791436E-01  0.3703330271704896592411E+00  0.9766576687827942526710E+00 -0.5517350488583696449529E-01  0.2075949960051302334296E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2016                             0                             0                             0                             0                             0                             0
 -0.4504936830858279339651E+00  0.8350873084007624791436E-01  0.3465905814218300795559E+00  0.9644545107638698988595E+00 -0.5517350488583697837308E-01  0.2584248072957329167565E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2017                             0                             0                             0                             0                             0                             0
 -0.4435588543010565709679E+00  0.8350873084007624791436E-01  0.3231789917990848248763E+00  0.9496078499693531016490E+00 -0.5517350488583697143419E-01  0.3085462941524253488446E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2018                             0                             0                             0                             0                             0                             0
 -0.4354082615280439605421E+00  0.8350873084007624791436E-01  0.3001624278420897962150E+00  0.9321583800645025785769E+00 -0.5517350488583696449529E-01  0.3578220770636358905037E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2019                             0                             0                             0                             0                             0                             0
 -0.4260642449750400850839E+00  0.8350873084007624791436E-01  0.2776039763527889947525E+00  0.9121539288334297168603E+00 -0.5517350488583697143419E-01  0.4061170945335235149543E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2020                             0                             0                             0                             0                             0                             0
 -0.4155524159419221041922E+00  0.8350873084007624791436E-01  0.2555654684786963226628E+00  0.8896493270864664903996E+00 -0.5517350488583697837308E-01  0.4532989732761478207657E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2021                             0                             0                             0                             0                             0                             0
 -0.4039015866214016314828E+00  0.8350873084007624791436E-01  0.2341073102380167303416E+00  0.8647062583727257445432E+00 -0.5517350488583697837308E-01  0.4992383910414474601502E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2022                             0                             0                             0                             0                             0                             0
 -0.3911436911268071359160E+00  0.8350873084007624791436E-01  0.2132883169509499077243E+00  0.8373930899097808966403E+00 -0.5517350488583697143419E-01  0.5438094310785369644989E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2023                             0                             0                             0                             0                             0                             0
 -0.3773136979628985421265E+00  0.8350873084007624791436E-01  0.1931655520309846219007E+00  0.8077846851938729200171E+00 -0.5517350488583697837308E-01  0.5868899272647708498241E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2024                             0                             0                             0                             0                             0                             0
 -0.3624495141796273411927E+00  0.8350873084007624791436E-01  0.1737941705780509105139E+00  0.7759621988042740836633E+00 -0.5517350488583697143419E-01  0.6283617989545899895631E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2025                             0                             0                             0                             0                             0                             0
 -0.3465918814715461260256E+00  0.8350873084007624791436E-01  0.1552272682022219907338E+00  0.7420128539642226739304E+00 -0.5517350488583697143419E-01  0.6681113746303691813822E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2026                             0                             0                             0                             0                             0                             0
 -0.3297842645076582979158E+00  0.8350873084007624791436E-01  0.1375157354923418062675E+00  0.7060297034681376482368E+00 -0.5517350488583698531198E-01  0.7060297034681374261922E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2027                             0                             0                             0                             0                             0                             0
 -0.3120727317977778358937E+00  0.8350873084007624791436E-01  0.1207081185284536450908E+00  0.6681113746303687372929E+00 -0.5517350488583697143419E-01  0.7420128539642231180196E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2028                             0                             0                             0                             0                             0                             0
 -0.2935058294219495822475E+00  0.8350873084007624791436E-01  0.1048504858203729850352E+00  0.6283617989545909887639E+00 -0.5517350488583697143419E-01  0.7759621988042733065072E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2029                             0                             0                             0                             0                             0                             0
 -0.2741344479690154822826E+00  0.8350873084007624791436E-01  0.8998630203710156205688E-01  0.5868899272647710718687E+00 -0.5517350488583697143419E-01  0.8077846851938726979725E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2030                             0                             0                             0                             0                             0                             0
 -0.2540116830490505295259E+00  0.8350873084007624791436E-01  0.7615630887319313480077E-01  0.5438094310785379636997E+00 -0.5517350488583697143419E-01  0.8373930899097802305064E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2031                             0                             0                             0                             0                             0                             0
 -0.2331926897619830130193E+00  0.8350873084007624791436E-01  0.6339841337859825065593E-01  0.4992383910414469605499E+00 -0.5517350488583696449529E-01  0.8647062583727259665878E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2032                             0                             0                             0                             0                             0                             0
 -0.2117345315213037537649E+00  0.8350873084007624791436E-01  0.5174758405807794447995E-01  0.4532989732761480428103E+00 -0.5517350488583697143419E-01  0.8896493270864663793773E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2033                             0                             0                             0                             0                             0                             0
 -0.1896960236472110816752E+00  0.8350873084007624791436E-01  0.4123575502495996358832E-01  0.4061170945335237925100E+00 -0.5517350488583697143419E-01  0.9121539288334296058380E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2034                             0                             0                             0                             0                             0                             0
 -0.1671375721579107243020E+00  0.8350873084007624791436E-01  0.3189173847195619915240E-01  0.3578220770636370007267E+00 -0.5517350488583697143419E-01  0.9321583800645022455100E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2035                             0                             0                             0                             0                             0                             0
 -0.1441210082009153070626E+00  0.8350873084007624791436E-01  0.2374114569894347770429E-01  0.3085462941524256264003E+00 -0.5517350488583697143419E-01  0.9496078499693529906267E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2036                             0                             0                             0                             0                             0                             0
 -0.1207094185781696638049E+00  0.8350873084007624791436E-01  0.1680631691417200368477E-01  0.2584248072957323616450E+00 -0.5517350488583696449529E-01  0.9644545107638700098818E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2037                             0                             0                             0                             0                             0                             0
 -0.9696697282951005636420E-01  0.8350873084007624791436E-01  0.1110626000130687796030E-01  0.2075949960051296505625E+00 -0.5517350488583696449529E-01  0.9766576687827943636933E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2038                             0                             0                             0                             0                             0                             0
 -0.7295874734841681363839E-01  0.8350873084007624791436E-01  0.6656598420140102945197E-02  0.1561961812602289667584E+00 -0.5517350488583697143419E-01  0.9861838760182271013122E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2039                             0                             0                             0                             0                             0                             0
 -0.4875054701214149438515E-01  0.8350873084007624791436E-01  0.3469528383773401447598E-02  0.1043692436395565886764E+00 -0.5517350488583697837308E-01  0.9930070217982949198898E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2040                             0                             0                             0                             0                             0                             0
 -0.2440872481511528052645E-01  0.8350873084007624791436E-01  0.1553785429646070692655E-02  0.5225623717668621132093E-01 -0.5517350488583696449529E-01  0.9971084043546851738427E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2041                             0                             0                             0                             0                             0                             0
  0.2829753959675105425265E-16  0.1043862266863211235579E+00  0.5166107738934999638047E-02 -0.5673639514979832001175E-16 -0.3761084501259890355840E+00  0.9265756492288292900383E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2042                             0                             0                             0                             0                             0                             0
  0.2418621916375647898367E-01  0.1043862266863211235579E+00  0.5799446177012335112977E-02 -0.4849322263381740383270E-01 -0.3761084501259890355840E+00  0.9253058095043029673832E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2043                             0                             0                             0                             0                             0                             0
  0.4830614558194844948558E-01  0.1043862266863211235579E+00  0.7697725554608236819831E-02 -0.9685352871511783423575E-01 -0.3761084501259889800728E+00  0.9214997708731436087959E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2044                             0                             0                             0                             0                             0                             0
  0.7229366821281942023791E-01  0.1043862266863211235579E+00  0.1085574281989654110703E-01 -0.1449483660064165568837E+00 -0.3761084501259890910951E+00  0.9151679654226848592558E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2045                             0                             0                             0                             0                             0                             0
  0.9608303892419030323158E-01  0.1043862266863211235579E+00  0.1526484206706424373579E-01 -0.1926459099017290843570E+00 -0.3761084501259890355840E+00  0.9063277481915475997098E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2046                             0                             0                             0                             0                             0                             0
  0.1196090527045200468947E+00  0.1043862266863211235579E+00  0.2091293826154749790902E-01 -0.2398154247486538048761E+00 -0.3761084501259890355840E+00  0.8950033496006868372064E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2047                             0                             0                             0                             0                             0                             0
  0.1428072263853100987152E+00  0.1043862266863211235579E+00  0.2778455036427168733937E-01 -0.2863276221857083969624E+00 -0.3761084501259890355840E+00  0.8812258090394905485354E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2048                             0                             0                             0                             0                             0                             0
  0.1656139753849866225188E+00  0.1043862266863211235579E+00  0.3586084376410303420357E-01 -0.3320550155127410252298E+00 -0.3761084501259890910951E+00  0.8650328897889720813907E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2049                             0                             0                             0                             0                             0                             0
  0.1879667879898191118482E+00  0.1043862266863211235579E+00  0.4511968190220899677101E-01 -0.3768722691231141674884E+00 -0.3761084501259890355840E+00  0.8464689755152409178507E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2050                             0                             0                             0                             0                             0                             0
  0.2098043966941827709327E+00  0.1043862266863211235579E+00  0.5553568694682681217145E-01 -0.4206565420398912236166E+00 -0.3761084501259890355840E+00  0.8255849486169595241591E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2051                             0                             0                             0                             0                             0                             0
  0.2310669461305324412503E+00  0.1043862266863211235579E+00  0.6708030935213687984131E-01 -0.4632878246144145339969E+00 -0.3761084501259890355840E+00  0.8024380507602253409516E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2052                             0                             0                             0                             0                             0                             0
  0.2516961571288049426265E+00  0.1043862266863211235579E+00  0.7972190611058321829674E-01 -0.5046492674644118547889E+00 -0.3761084501259890910951E+00  0.7770917259831422452265E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2053                             0                             0                             0                             0                             0                             0
  0.2716354864555726722486E+00  0.1043862266863211235579E+00  0.9342582748415739768433E-01 -0.5446275017500294968187E+00 -0.3761084501259890355840E+00  0.7496154468001230419816E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2054                             0                             0                             0                             0                             0                             0
  0.2908302817951168850463E+00  0.1043862266863211235579E+00  0.1081545119769224960748E+00 -0.5831129499099438895371E+00 -0.3761084501259889800728E+00  0.7200845237825554967515E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2055                             0                             0                             0                             0                             0                             0
  0.3092279315476256784656E+00  0.1043862266863211235579E+00  0.1238675892884619766932E+00 -0.6200001260058393137697E+00 -0.3761084501259890355840E+00  0.6885798991377615196896E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2056                             0                             0                             0                             0                             0                             0
  0.3267780090339323928461E+00  0.1043862266863211235579E+00  0.1405219909660675448038E+00 -0.6551879248520329213079E+00 -0.3761084501259890355840E+00  0.6551879248520330323302E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2057                             0                             0                             0                             0                             0                             0
  0.3434324107115380719790E+00  0.1043862266863211235579E+00  0.1580720684523743146954E+00 -0.6885798991377616307119E+00 -0.3761084501259890355840E+00  0.6200001260058393137697E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2058                             0                             0                             0                             0                             0                             0
  0.3591454880230775525973E+00  0.1043862266863211235579E+00  0.1764697182048831636259E+00 -0.7200845237825556077738E+00 -0.3761084501259890355840E+00  0.5831129499099437785148E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2059                             0                             0                             0                             0                             0                             0
  0.3738741725158425954767E+00  0.1043862266863211235579E+00  0.1956645135444273209124E+00 -0.7496154468001230419816E+00 -0.3761084501259890355840E+00  0.5446275017500294968187E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2060                             0                             0                             0                             0                             0                             0
  0.3875780938894167748643E+00  0.1043862266863211235579E+00  0.2156038428711950505345E+00 -0.7770917259831422452265E+00 -0.3761084501259890910951E+00  0.5046492674644118547889E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2061                             0                             0                             0                             0                             0                             0
  0.4002196906478630578086E+00  0.1043862266863211235579E+00  0.2362330538694674963995E+00 -0.8024380507602252299293E+00 -0.3761084501259889800728E+00  0.4632878246144146450192E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2062                             0                             0                             0                             0                             0                             0
  0.4117643130531732365007E+00  0.1043862266863211235579E+00  0.2574956033058172222283E+00 -0.8255849486169595241591E+00 -0.3761084501259890355840E+00  0.4206565420398911681055E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2063                             0                             0                             0                             0                             0                             0
  0.4221803180977909963900E+00  0.1043862266863211235579E+00  0.2793332120101808535573E+00 -0.8464689755152409178507E+00 -0.3761084501259890910951E+00  0.3768722691231142785107E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2064                             0                             0                             0                             0                             0                             0
  0.4314391562358969589575E+00  0.1043862266863211235579E+00  0.3016860246150133706422E+00 -0.8650328897889720813907E+00 -0.3761084501259890910951E+00  0.3320550155127409697187E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2065                             0                             0                             0                             0                             0                             0
  0.4395154496357283058217E+00  0.1043862266863211235579E+00  0.3244927736146899222014E+00 -0.8812258090394905485354E+00 -0.3761084501259890355840E+00  0.2863276221857083969624E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2066                             0                             0                             0                             0                             0                             0
  0.4463870617384524952520E+00  0.1043862266863211235579E+00  0.3476909472954800017774E+00 -0.8950033496006868372064E+00 -0.3761084501259890355840E+00  0.2398154247486537493650E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2067                             0                             0                             0                             0                             0                             0
  0.4520351579329357494252E+00  0.1043862266863211235579E+00  0.3712169610758098148295E+00 -0.9063277481915477107322E+00 -0.3761084501259890910951E+00  0.1926459099017288345568E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2068                             0                             0                             0                             0                             0                             0
  0.4564442571801034520540E+00  0.1043862266863211235579E+00  0.3950063317871805868009E+00 -0.9151679654226848592558E+00 -0.3761084501259890910951E+00  0.1449483660064165291281E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2069                             0                             0                             0                             0                             0                             0
  0.4596022744453917563412E+00  0.1043862266863211235579E+00  0.4189938544180515922477E+00 -0.9214997708731436087959E+00 -0.3761084501259889800728E+00  0.9685352871511777872460E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2070                             0                             0                             0                             0                             0                             0
  0.4615005538229876580480E+00  0.1043862266863211235579E+00  0.4431137808362436425469E+00 -0.9253058095043029673832E+00 -0.3761084501259890355840E+00  0.4849322263381714015473E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2071                             0                             0                             0                             0                             0                             0
  0.4621338922610649935230E+00  0.1043862266863211235579E+00  0.4672999999999998821387E+00 -0.9265756492288292900383E+00 -0.3761084501259890355840E+00  0.2057411239661697899358E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2072                             0                             0                             0                             0                             0                             0
  0.4615005538229876580480E+00  0.1043862266863211235579E+00  0.4914862191637563437752E+00 -0.9253058095043029673832E+00 -0.3761084501259890355840E+00 -0.4849322263381714015473E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2073                             0                             0                             0                             0                             0                             0
  0.4596022744453917563412E+00  0.1043862266863211235579E+00  0.5156061455819483940743E+00 -0.9214997708731436087959E+00 -0.3761084501259889800728E+00 -0.9685352871511777872460E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2074                             0                             0                             0                             0                             0                             0
  0.4564442571801034520540E+00  0.1043862266863211235579E+00  0.5395936682128193995212E+00 -0.9151679654226848592558E+00 -0.3761084501259890910951E+00 -0.1449483660064165291281E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2075                             0                             0                             0                             0                             0                             0
  0.4520351579329357494252E+00  0.1043862266863211235579E+00  0.5633830389241902825148E+00 -0.9063277481915475997098E+00 -0.3761084501259889800728E+00 -0.1926459099017290288458E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2076                             0                             0                             0                             0                             0                             0
  0.4463870617384524952520E+00  0.1043862266863211235579E+00  0.5869090527045199845446E+00 -0.8950033496006868372064E+00 -0.3761084501259890355840E+00 -0.2398154247486537493650E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2077                             0                             0                             0                             0                             0                             0
  0.4395154496357283058217E+00  0.1043862266863211235579E+00  0.6101072263853100086095E+00 -0.8812258090394905485354E+00 -0.3761084501259890355840E+00 -0.2863276221857083969624E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2078                             0                             0                             0                             0                             0                             0
  0.4314391562358969589575E+00  0.1043862266863211235579E+00  0.6329139753849866156798E+00 -0.8650328897889720813907E+00 -0.3761084501259890910951E+00 -0.3320550155127409697187E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2079                             0                             0                             0                             0                             0                             0
  0.4221803180977910519012E+00  0.1043862266863211235579E+00  0.6552667879898190772536E+00 -0.8464689755152409178507E+00 -0.3761084501259890355840E+00 -0.3768722691231141674884E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2080                             0                             0                             0                             0                             0                             0
  0.4117643130531732365007E+00  0.1043862266863211235579E+00  0.6771043966941827640937E+00 -0.8255849486169595241591E+00 -0.3761084501259890355840E+00 -0.4206565420398911681055E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2081                             0                             0                             0                             0                             0                             0
  0.4002196906478631133197E+00  0.1043862266863211235579E+00  0.6983669461305324066558E+00 -0.8024380507602253409516E+00 -0.3761084501259890355840E+00 -0.4632878246144144784857E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2082                             0                             0                             0                             0                             0                             0
  0.3875780938894168303754E+00  0.1043862266863211235579E+00  0.7189961571288048247652E+00 -0.7770917259831423562488E+00 -0.3761084501259889800728E+00 -0.5046492674644116327443E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2083                             0                             0                             0                             0                             0                             0
  0.3738741725158425954767E+00  0.1043862266863211235579E+00  0.7389354864555726098985E+00 -0.7496154468001230419816E+00 -0.3761084501259890355840E+00 -0.5446275017500294968187E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2084                             0                             0                             0                             0                             0                             0
  0.3591454880230776081085E+00  0.1043862266863211235579E+00  0.7581302817951167671850E+00 -0.7200845237825556077738E+00 -0.3761084501259890355840E+00 -0.5831129499099436674925E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2085                             0                             0                             0                             0                             0                             0
  0.3434324107115381830013E+00  0.1043862266863211235579E+00  0.7765279315476255606043E+00 -0.6885798991377618527565E+00 -0.3761084501259890910951E+00 -0.6200001260058390917251E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2086                             0                             0                             0                             0                             0                             0
  0.3267780090339324483573E+00  0.1043862266863211235579E+00  0.7940780090339323304960E+00 -0.6551879248520330323302E+00 -0.3761084501259890355840E+00 -0.6551879248520329213079E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2087                             0                             0                             0                             0                             0                             0
  0.3092279315476257339768E+00  0.1043862266863211235579E+00  0.8107324107115380096289E+00 -0.6200001260058394247920E+00 -0.3761084501259890355840E+00 -0.6885798991377615196896E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2088                             0                             0                             0                             0                             0                             0
  0.2908302817951168295352E+00  0.1043862266863211235579E+00  0.8264454880230776012695E+00 -0.5831129499099437785148E+00 -0.3761084501259890355840E+00 -0.7200845237825556077738E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2089                             0                             0                             0                             0                             0                             0
  0.2716354864555726722486E+00  0.1043862266863211235579E+00  0.8411741725158425886377E+00 -0.5446275017500294968187E+00 -0.3761084501259890355840E+00 -0.7496154468001230419816E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2090                             0                             0                             0                             0                             0                             0
  0.2516961571288049981376E+00  0.1043862266863211235579E+00  0.8548780938894167125142E+00 -0.5046492674644119658112E+00 -0.3761084501259890355840E+00 -0.7770917259831421342042E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2091                             0                             0                             0                             0                             0                             0
  0.2310669461305324412503E+00  0.1043862266863211235579E+00  0.8675196906478630509696E+00 -0.4632878246144145339969E+00 -0.3761084501259890355840E+00 -0.8024380507602253409516E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2092                             0                             0                             0                             0                             0                             0
  0.2098043966941827709327E+00  0.1043862266863211235579E+00  0.8790643130531732296618E+00 -0.4206565420398912236166E+00 -0.3761084501259890355840E+00 -0.8255849486169595241591E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2093                             0                             0                             0                             0                             0                             0
  0.1879667879898190008259E+00  0.1043862266863211235579E+00  0.8894803180977910450622E+00 -0.3768722691231140009549E+00 -0.3761084501259889800728E+00 -0.8464689755152409178507E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2094                             0                             0                             0                             0                             0                             0
  0.1656139753849865114965E+00  0.1043862266863211235579E+00  0.8987391562358969521185E+00 -0.3320550155127408586964E+00 -0.3761084501259890355840E+00 -0.8650328897889720813907E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2095                             0                             0                             0                             0                             0                             0
  0.1428072263853100987152E+00  0.1043862266863211235579E+00  0.9068154496357283544938E+00 -0.2863276221857083969624E+00 -0.3761084501259890355840E+00 -0.8812258090394905485354E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2096                             0                             0                             0                             0                             0                             0
  0.1196090527045199358724E+00  0.1043862266863211235579E+00  0.9136870617384524884130E+00 -0.2398154247486536105871E+00 -0.3761084501259889800728E+00 -0.8950033496006868372064E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2097                             0                             0                             0                             0                             0                             0
  0.9608303892419020608706E-01  0.1043862266863211235579E+00  0.9193351579329357425863E+00 -0.1926459099017288900679E+00 -0.3761084501259890910951E+00 -0.9063277481915477107322E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2098                             0                             0                             0                             0                             0                             0
  0.7229366821281942023791E-01  0.1043862266863211235579E+00  0.9237442571801034452150E+00 -0.1449483660064165568837E+00 -0.3761084501259890910951E+00 -0.9151679654226848592558E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2099                             0                             0                             0                             0                             0                             0
  0.4830614558194835234106E-01  0.1043862266863211235579E+00  0.9269022744453918605245E+00 -0.9685352871511762606893E-01 -0.3761084501259890910951E+00 -0.9214997708731437198182E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2100                             0                             0                             0                             0                             0                             0
  0.2418621916375637490026E-01  0.1043862266863211235579E+00  0.9288005538229876512091E+00 -0.4849322263381720260478E-01 -0.3761084501259890355840E+00 -0.9253058095043029673832E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2101                             0                             0                             0                             0                             0                             0
  0.2335262146559013988518E-15  0.1043862266863211235579E+00  0.9294338922610649866840E+00 -0.4682186430821379245352E-15 -0.3761084501259890355840E+00 -0.9265756492288292900383E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2102                             0                             0                             0                             0                             0                             0
 -0.2418621916375631938911E-01  0.1043862266863211235579E+00  0.9288005538229876512091E+00  0.4849322263381708464358E-01 -0.3761084501259890355840E+00 -0.9253058095043029673832E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2103                             0                             0                             0                             0                             0                             0
 -0.4830614558194828989102E-01  0.1043862266863211235579E+00  0.9269022744453918605245E+00  0.9685352871511751504663E-01 -0.3761084501259890910951E+00 -0.9214997708731437198182E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2104                             0                             0                             0                             0                             0                             0
 -0.7229366821281936472676E-01  0.1043862266863211235579E+00  0.9237442571801034452150E+00  0.1449483660064164736170E+00 -0.3761084501259890355840E+00 -0.9151679654226848592558E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2105                             0                             0                             0                             0                             0                             0
 -0.9608303892419015057591E-01  0.1043862266863211235579E+00  0.9193351579329357425863E+00  0.1926459099017287790456E+00 -0.3761084501259890910951E+00 -0.9063277481915477107322E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2106                             0                             0                             0                             0                             0                             0
 -0.1196090527045198803613E+00  0.1043862266863211235579E+00  0.9136870617384524884130E+00  0.2398154247486534995648E+00 -0.3761084501259890355840E+00 -0.8950033496006869482287E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2107                             0                             0                             0                             0                             0                             0
 -0.1428072263853100432041E+00  0.1043862266863211235579E+00  0.9068154496357283544938E+00  0.2863276221857083414513E+00 -0.3761084501259890355840E+00 -0.8812258090394906595577E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2108                             0                             0                             0                             0                             0                             0
 -0.1656139753849864559854E+00  0.1043862266863211235579E+00  0.8987391562358970631408E+00  0.3320550155127407476741E+00 -0.3761084501259889800728E+00 -0.8650328897889721924130E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2109                             0                             0                             0                             0                             0                             0
 -0.1879667879898191396038E+00  0.1043862266863211235579E+00  0.8894803180977910450622E+00  0.3768722691231142229995E+00 -0.3761084501259890910951E+00 -0.8464689755152409178507E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2110                             0                             0                             0                             0                             0                             0
 -0.2098043966941827154216E+00  0.1043862266863211235579E+00  0.8790643130531732296618E+00  0.4206565420398911125943E+00 -0.3761084501259890355840E+00 -0.8255849486169595241591E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2111                             0                             0                             0                             0                             0                             0
 -0.2310669461305323857392E+00  0.1043862266863211235579E+00  0.8675196906478630509696E+00  0.4632878246144144229746E+00 -0.3761084501259890355840E+00 -0.8024380507602253409516E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2112                             0                             0                             0                             0                             0                             0
 -0.2516961571288049426265E+00  0.1043862266863211235579E+00  0.8548780938894167125142E+00  0.5046492674644118547889E+00 -0.3761084501259889800728E+00 -0.7770917259831421342042E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2113                             0                             0                             0                             0                             0                             0
 -0.2716354864555726167374E+00  0.1043862266863211235579E+00  0.8411741725158425886377E+00  0.5446275017500293857964E+00 -0.3761084501259889800728E+00 -0.7496154468001230419816E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2114                             0                             0                             0                             0                             0                             0
 -0.2908302817951167740240E+00  0.1043862266863211235579E+00  0.8264454880230776012695E+00  0.5831129499099436674925E+00 -0.3761084501259890355840E+00 -0.7200845237825556077738E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2115                             0                             0                             0                             0                             0                             0
 -0.3092279315476256784656E+00  0.1043862266863211235579E+00  0.8107324107115381206512E+00  0.6200001260058393137697E+00 -0.3761084501259890355840E+00 -0.6885798991377616307119E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2116                             0                             0                             0                             0                             0                             0
 -0.3267780090339323928461E+00  0.1043862266863211235579E+00  0.7940780090339324415183E+00  0.6551879248520329213079E+00 -0.3761084501259890355840E+00 -0.6551879248520330323302E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2117                             0                             0                             0                             0                             0                             0
 -0.3434324107115379609567E+00  0.1043862266863211235579E+00  0.7765279315476256716266E+00  0.6885798991377614086673E+00 -0.3761084501259890355840E+00 -0.6200001260058394247920E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2118                             0                             0                             0                             0                             0                             0
 -0.3591454880230774415750E+00  0.1043862266863211235579E+00  0.7581302817951169892297E+00  0.7200845237825553857292E+00 -0.3761084501259890355840E+00 -0.5831129499099441115817E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2119                             0                             0                             0                             0                             0                             0
 -0.3738741725158425399655E+00  0.1043862266863211235579E+00  0.7389354864555727209208E+00  0.7496154468001229309593E+00 -0.3761084501259890355840E+00 -0.5446275017500296078410E+00
