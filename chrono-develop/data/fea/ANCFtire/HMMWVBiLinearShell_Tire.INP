                          1836                             1                             3                          1836                          1837                          1956                          1957
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1837                             1                             3                          1837                          1838                          1957                          1958
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1838                             1                             3                          1838                          1839                          1958                          1959
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1839                             1                             3                          1839                          1840                          1959                          1960
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1840                             1                             3                          1840                          1841                          1960                          1961
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1841                             1                             3                          1841                          1842                          1961                          1962
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1842                             1                             3                          1842                          1843                          1962                          1963
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1843                             1                             3                          1843                          1844                          1963                          1964
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1844                             1                             3                          1844                          1845                          1964                          1965
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1845                             1                             3                          1845                          1846                          1965                          1966
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1846                             1                             3                          1846                          1847                          1966                          1967
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1847                             1                             3                          1847                          1848                          1967                          1968
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1848                             1                             3                          1848                          1849                          1968                          1969
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1849                             1                             3                          1849                          1850                          1969                          1970
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1850                             1                             3                          1850                          1851                          1970                          1971
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1851                             1                             3                          1851                          1852                          1971                          1972
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1852                             1                             3                          1852                          1853                          1972                          1973
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1853                             1                             3                          1853                          1854                          1973                          1974
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1854                             1                             3                          1854                          1855                          1974                          1975
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1855                             1                             3                          1855                          1856                          1975                          1976
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1856                             1                             3                          1856                          1857                          1976                          1977
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1857                             1                             3                          1857                          1858                          1977                          1978
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1858                             1                             3                          1858                          1859                          1978                          1979
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1859                             1                             3                          1859                          1860                          1979                          1980
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1860                             1                             3                          1860                          1861                          1980                          1981
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1861                             1                             3                          1861                          1862                          1981                          1982
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1862                             1                             3                          1862                          1863                          1982                          1983
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1863                             1                             3                          1863                          1864                          1983                          1984
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1864                             1                             3                          1864                          1865                          1984                          1985
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1865                             1                             3                          1865                          1866                          1985                          1986
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1866                             1                             3                          1866                          1867                          1986                          1987
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1867                             1                             3                          1867                          1868                          1987                          1988
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1868                             1                             3                          1868                          1869                          1988                          1989
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1869                             1                             3                          1869                          1870                          1989                          1990
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1870                             1                             3                          1870                          1871                          1990                          1991
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1871                             1                             3                          1871                          1872                          1991                          1992
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1872                             1                             3                          1872                          1873                          1992                          1993
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1873                             1                             3                          1873                          1874                          1993                          1994
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1874                             1                             3                          1874                          1875                          1994                          1995
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1875                             1                             3                          1875                          1876                          1995                          1996
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1876                             1                             3                          1876                          1877                          1996                          1997
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1877                             1                             3                          1877                          1878                          1997                          1998
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1878                             1                             3                          1878                          1879                          1998                          1999
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1879                             1                             3                          1879                          1880                          1999                          2000
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1880                             1                             3                          1880                          1881                          2000                          2001
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1881                             1                             3                          1881                          1882                          2001                          2002
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1882                             1                             3                          1882                          1883                          2002                          2003
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1883                             1                             3                          1883                          1884                          2003                          2004
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1884                             1                             3                          1884                          1885                          2004                          2005
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1885                             1                             3                          1885                          1886                          2005                          2006
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1886                             1                             3                          1886                          1887                          2006                          2007
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1887                             1                             3                          1887                          1888                          2007                          2008
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1888                             1                             3                          1888                          1889                          2008                          2009
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1889                             1                             3                          1889                          1890                          2009                          2010
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1890                             1                             3                          1890                          1891                          2010                          2011
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1891                             1                             3                          1891                          1892                          2011                          2012
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1892                             1                             3                          1892                          1893                          2012                          2013
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1893                             1                             3                          1893                          1894                          2013                          2014
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1894                             1                             3                          1894                          1895                          2014                          2015
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1895                             1                             3                          1895                          1896                          2015                          2016
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1896                             1                             3                          1896                          1897                          2016                          2017
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1897                             1                             3                          1897                          1898                          2017                          2018
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1898                             1                             3                          1898                          1899                          2018                          2019
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1899                             1                             3                          1899                          1900                          2019                          2020
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1900                             1                             3                          1900                          1901                          2020                          2021
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1901                             1                             3                          1901                          1902                          2021                          2022
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1902                             1                             3                          1902                          1903                          2022                          2023
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1903                             1                             3                          1903                          1904                          2023                          2024
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1904                             1                             3                          1904                          1905                          2024                          2025
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1905                             1                             3                          1905                          1906                          2025                          2026
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1906                             1                             3                          1906                          1907                          2026                          2027
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1907                             1                             3                          1907                          1908                          2027                          2028
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1908                             1                             3                          1908                          1909                          2028                          2029
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1909                             1                             3                          1909                          1910                          2029                          2030
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1910                             1                             3                          1910                          1911                          2030                          2031
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1911                             1                             3                          1911                          1912                          2031                          2032
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1912                             1                             3                          1912                          1913                          2032                          2033
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1913                             1                             3                          1913                          1914                          2033                          2034
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1914                             1                             3                          1914                          1915                          2034                          2035
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1915                             1                             3                          1915                          1916                          2035                          2036
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1916                             1                             3                          1916                          1917                          2036                          2037
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1917                             1                             3                          1917                          1918                          2037                          2038
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1918                             1                             3                          1918                          1919                          2038                          2039
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1919                             1                             3                          1919                          1920                          2039                          2040
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1920                             1                             3                          1920                          1801                          2040                          1921
  0.2442593239710638686191E-01  0.2087836460363719573441E-01
                          1921                             1                             3                          1921                          1922                          2041                          2042
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1922                             1                             3                          1922                          1923                          2042                          2043
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1923                             1                             3                          1923                          1924                          2043                          2044
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1924                             1                             3                          1924                          1925                          2044                          2045
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1925                             1                             3                          1925                          1926                          2045                          2046
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1926                             1                             3                          1926                          1927                          2046                          2047
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1927                             1                             3                          1927                          1928                          2047                          2048
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1928                             1                             3                          1928                          1929                          2048                          2049
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1929                             1                             3                          1929                          1930                          2049                          2050
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1930                             1                             3                          1930                          1931                          2050                          2051
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1931                             1                             3                          1931                          1932                          2051                          2052
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1932                             1                             3                          1932                          1933                          2052                          2053
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1933                             1                             3                          1933                          1934                          2053                          2054
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1934                             1                             3                          1934                          1935                          2054                          2055
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1935                             1                             3                          1935                          1936                          2055                          2056
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1936                             1                             3                          1936                          1937                          2056                          2057
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1937                             1                             3                          1937                          1938                          2057                          2058
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1938                             1                             3                          1938                          1939                          2058                          2059
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1939                             1                             3                          1939                          1940                          2059                          2060
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1940                             1                             3                          1940                          1941                          2060                          2061
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1941                             1                             3                          1941                          1942                          2061                          2062
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1942                             1                             3                          1942                          1943                          2062                          2063
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1943                             1                             3                          1943                          1944                          2063                          2064
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1944                             1                             3                          1944                          1945                          2064                          2065
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1945                             1                             3                          1945                          1946                          2065                          2066
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1946                             1                             3                          1946                          1947                          2066                          2067
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1947                             1                             3                          1947                          1948                          2067                          2068
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1948                             1                             3                          1948                          1949                          2068                          2069
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1949                             1                             3                          1949                          1950                          2069                          2070
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1950                             1                             3                          1950                          1951                          2070                          2071
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1951                             1                             3                          1951                          1952                          2071                          2072
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1952                             1                             3                          1952                          1953                          2072                          2073
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1953                             1                             3                          1953                          1954                          2073                          2074
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1954                             1                             3                          1954                          1955                          2074                          2075
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1955                             1                             3                          1955                          1956                          2075                          2076
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1956                             1                             3                          1956                          1957                          2076                          2077
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1957                             1                             3                          1957                          1958                          2077                          2078
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1958                             1                             3                          1958                          1959                          2078                          2079
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1959                             1                             3                          1959                          1960                          2079                          2080
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1960                             1                             3                          1960                          1961                          2080                          2081
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1961                             1                             3                          1961                          1962                          2081                          2082
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1962                             1                             3                          1962                          1963                          2082                          2083
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1963                             1                             3                          1963                          1964                          2083                          2084
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1964                             1                             3                          1964                          1965                          2084                          2085
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1965                             1                             3                          1965                          1966                          2085                          2086
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1966                             1                             3                          1966                          1967                          2086                          2087
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1967                             1                             3                          1967                          1968                          2087                          2088
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1968                             1                             3                          1968                          1969                          2088                          2089
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1969                             1                             3                          1969                          1970                          2089                          2090
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1970                             1                             3                          1970                          1971                          2090                          2091
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1971                             1                             3                          1971                          1972                          2091                          2092
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1972                             1                             3                          1972                          1973                          2092                          2093
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1973                             1                             3                          1973                          1974                          2093                          2094
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1974                             1                             3                          1974                          1975                          2094                          2095
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1975                             1                             3                          1975                          1976                          2095                          2096
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1976                             1                             3                          1976                          1977                          2096                          2097
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1977                             1                             3                          1977                          1978                          2097                          2098
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1978                             1                             3                          1978                          1979                          2098                          2099
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1979                             1                             3                          1979                          1980                          2099                          2100
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1980                             1                             3                          1980                          1981                          2100                          2101
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1981                             1                             3                          1981                          1982                          2101                          2102
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1982                             1                             3                          1982                          1983                          2102                          2103
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1983                             1                             3                          1983                          1984                          2103                          2104
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1984                             1                             3                          1984                          1985                          2104                          2105
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1985                             1                             3                          1985                          1986                          2105                          2106
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1986                             1                             3                          1986                          1987                          2106                          2107
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1987                             1                             3                          1987                          1988                          2107                          2108
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1988                             1                             3                          1988                          1989                          2108                          2109
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1989                             1                             3                          1989                          1990                          2109                          2110
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1990                             1                             3                          1990                          1991                          2110                          2111
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1991                             1                             3                          1991                          1992                          2111                          2112
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1992                             1                             3                          1992                          1993                          2112                          2113
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1993                             1                             3                          1993                          1994                          2113                          2114
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1994                             1                             3                          1994                          1995                          2114                          2115
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1995                             1                             3                          1995                          1996                          2115                          2116
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1996                             1                             3                          1996                          1997                          2116                          2117
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1997                             1                             3                          1997                          1998                          2117                          2118
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1998                             1                             3                          1998                          1999                          2118                          2119
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          1999                             1                             3                          1999                          2000                          2119                          2120
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2000                             1                             3                          2000                          2001                          2120                          2121
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2001                             1                             3                          2001                          2002                          2121                          2122
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2002                             1                             3                          2002                          2003                          2122                          2123
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2003                             1                             3                          2003                          2004                          2123                          2124
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2004                             1                             3                          2004                          2005                          2124                          2125
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2005                             1                             3                          2005                          2006                          2125                          2126
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2006                             1                             3                          2006                          2007                          2126                          2127
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2007                             1                             3                          2007                          2008                          2127                          2128
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2008                             1                             3                          2008                          2009                          2128                          2129
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2009                             1                             3                          2009                          2010                          2129                          2130
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2010                             1                             3                          2010                          2011                          2130                          2131
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2011                             1                             3                          2011                          2012                          2131                          2132
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2012                             1                             3                          2012                          2013                          2132                          2133
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2013                             1                             3                          2013                          2014                          2133                          2134
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2014                             1                             3                          2014                          2015                          2134                          2135
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2015                             1                             3                          2015                          2016                          2135                          2136
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2016                             1                             3                          2016                          2017                          2136                          2137
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2017                             1                             3                          2017                          2018                          2137                          2138
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2018                             1                             3                          2018                          2019                          2138                          2139
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2019                             1                             3                          2019                          2020                          2139                          2140
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2020                             1                             3                          2020                          2021                          2140                          2141
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2021                             1                             3                          2021                          2022                          2141                          2142
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2022                             1                             3                          2022                          2023                          2142                          2143
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2023                             1                             3                          2023                          2024                          2143                          2144
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2024                             1                             3                          2024                          2025                          2144                          2145
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2025                             1                             3                          2025                          2026                          2145                          2146
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2026                             1                             3                          2026                          2027                          2146                          2147
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2027                             1                             3                          2027                          2028                          2147                          2148
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2028                             1                             3                          2028                          2029                          2148                          2149
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2029                             1                             3                          2029                          2030                          2149                          2150
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2030                             1                             3                          2030                          2031                          2150                          2151
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2031                             1                             3                          2031                          2032                          2151                          2152
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2032                             1                             3                          2032                          2033                          2152                          2153
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2033                             1                             3                          2033                          2034                          2153                          2154
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2034                             1                             3                          2034                          2035                          2154                          2155
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2035                             1                             3                          2035                          2036                          2155                          2156
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2036                             1                             3                          2036                          2037                          2156                          2157
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2037                             1                             3                          2037                          2038                          2157                          2158
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2038                             1                             3                          2038                          2039                          2158                          2159
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2039                             1                             3                          2039                          2040                          2159                          2160
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2040                             1                             3                          2040                          1921                          2160                          2041
  0.2430857769130332496355E-01  0.2130598452915483109749E-01
                          2041                             1                             3                          2041                          2042                          2161                          2162
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2042                             1                             3                          2042                          2043                          2162                          2163
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2043                             1                             3                          2043                          2044                          2163                          2164
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2044                             1                             3                          2044                          2045                          2164                          2165
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2045                             1                             3                          2045                          2046                          2165                          2166
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2046                             1                             3                          2046                          2047                          2166                          2167
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2047                             1                             3                          2047                          2048                          2167                          2168
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2048                             1                             3                          2048                          2049                          2168                          2169
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2049                             1                             3                          2049                          2050                          2169                          2170
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2050                             1                             3                          2050                          2051                          2170                          2171
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2051                             1                             3                          2051                          2052                          2171                          2172
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2052                             1                             3                          2052                          2053                          2172                          2173
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2053                             1                             3                          2053                          2054                          2173                          2174
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2054                             1                             3                          2054                          2055                          2174                          2175
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2055                             1                             3                          2055                          2056                          2175                          2176
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2056                             1                             3                          2056                          2057                          2176                          2177
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2057                             1                             3                          2057                          2058                          2177                          2178
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2058                             1                             3                          2058                          2059                          2178                          2179
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2059                             1                             3                          2059                          2060                          2179                          2180
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2060                             1                             3                          2060                          2061                          2180                          2181
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2061                             1                             3                          2061                          2062                          2181                          2182
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2062                             1                             3                          2062                          2063                          2182                          2183
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2063                             1                             3                          2063                          2064                          2183                          2184
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2064                             1                             3                          2064                          2065                          2184                          2185
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2065                             1                             3                          2065                          2066                          2185                          2186
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2066                             1                             3                          2066                          2067                          2186                          2187
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2067                             1                             3                          2067                          2068                          2187                          2188
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2068                             1                             3                          2068                          2069                          2188                          2189
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2069                             1                             3                          2069                          2070                          2189                          2190
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2070                             1                             3                          2070                          2071                          2190                          2191
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2071                             1                             3                          2071                          2072                          2191                          2192
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2072                             1                             3                          2072                          2073                          2192                          2193
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2073                             1                             3                          2073                          2074                          2193                          2194
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2074                             1                             3                          2074                          2075                          2194                          2195
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2075                             1                             3                          2075                          2076                          2195                          2196
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2076                             1                             3                          2076                          2077                          2196                          2197
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2077                             1                             3                          2077                          2078                          2197                          2198
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2078                             1                             3                          2078                          2079                          2198                          2199
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2079                             1                             3                          2079                          2080                          2199                          2200
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2080                             1                             3                          2080                          2081                          2200                          2201
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2081                             1                             3                          2081                          2082                          2201                          2202
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2082                             1                             3                          2082                          2083                          2202                          2203
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2083                             1                             3                          2083                          2084                          2203                          2204
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2084                             1                             3                          2084                          2085                          2204                          2205
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2085                             1                             3                          2085                          2086                          2205                          2206
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2086                             1                             3                          2086                          2087                          2206                          2207
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2087                             1                             3                          2087                          2088                          2207                          2208
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2088                             1                             3                          2088                          2089                          2208                          2209
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2089                             1                             3                          2089                          2090                          2209                          2210
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2090                             1                             3                          2090                          2091                          2210                          2211
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2091                             1                             3                          2091                          2092                          2211                          2212
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2092                             1                             3                          2092                          2093                          2212                          2213
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2093                             1                             3                          2093                          2094                          2213                          2214
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2094                             1                             3                          2094                          2095                          2214                          2215
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2095                             1                             3                          2095                          2096                          2215                          2216
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2096                             1                             3                          2096                          2097                          2216                          2217
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2097                             1                             3                          2097                          2098                          2217                          2218
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2098                             1                             3                          2098                          2099                          2218                          2219
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2099                             1                             3                          2099                          2100                          2219                          2220
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2100                             1                             3                          2100                          2101                          2220                          2221
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2101                             1                             3                          2101                          2102                          2221                          2222
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2102                             1                             3                          2102                          2103                          2222                          2223
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2103                             1                             3                          2103                          2104                          2223                          2224
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2104                             1                             3                          2104                          2105                          2224                          2225
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2105                             1                             3                          2105                          2106                          2225                          2226
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2106                             1                             3                          2106                          2107                          2226                          2227
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2107                             1                             3                          2107                          2108                          2227                          2228
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2108                             1                             3                          2108                          2109                          2228                          2229
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2109                             1                             3                          2109                          2110                          2229                          2230
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2110                             1                             3                          2110                          2111                          2230                          2231
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2111                             1                             3                          2111                          2112                          2231                          2232
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2112                             1                             3                          2112                          2113                          2232                          2233
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2113                             1                             3                          2113                          2114                          2233                          2234
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2114                             1                             3                          2114                          2115                          2234                          2235
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2115                             1                             3                          2115                          2116                          2235                          2236
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2116                             1                             3                          2116                          2117                          2236                          2237
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2117                             1                             3                          2117                          2118                          2237                          2238
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2118                             1                             3                          2118                          2119                          2238                          2239
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2119                             1                             3                          2119                          2120                          2239                          2240
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2120                             1                             3                          2120                          2121                          2240                          2241
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2121                             1                             3                          2121                          2122                          2241                          2242
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2122                             1                             3                          2122                          2123                          2242                          2243
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2123                             1                             3                          2123                          2124                          2243                          2244
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2124                             1                             3                          2124                          2125                          2244                          2245
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2125                             1                             3                          2125                          2126                          2245                          2246
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2126                             1                             3                          2126                          2127                          2246                          2247
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2127                             1                             3                          2127                          2128                          2247                          2248
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2128                             1                             3                          2128                          2129                          2248                          2249
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2129                             1                             3                          2129                          2130                          2249                          2250
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2130                             1                             3                          2130                          2131                          2250                          2251
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2131                             1                             3                          2131                          2132                          2251                          2252
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2132                             1                             3                          2132                          2133                          2252                          2253
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2133                             1                             3                          2133                          2134                          2253                          2254
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2134                             1                             3                          2134                          2135                          2254                          2255
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2135                             1                             3                          2135                          2136                          2255                          2256
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2136                             1                             3                          2136                          2137                          2256                          2257
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2137                             1                             3                          2137                          2138                          2257                          2258
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2138                             1                             3                          2138                          2139                          2258                          2259
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2139                             1                             3                          2139                          2140                          2259                          2260
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2140                             1                             3                          2140                          2141                          2260                          2261
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2141                             1                             3                          2141                          2142                          2261                          2262
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2142                             1                             3                          2142                          2143                          2262                          2263
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2143                             1                             3                          2143                          2144                          2263                          2264
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2144                             1                             3                          2144                          2145                          2264                          2265
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2145                             1                             3                          2145                          2146                          2265                          2266
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2146                             1                             3                          2146                          2147                          2266                          2267
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2147                             1                             3                          2147                          2148                          2267                          2268
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2148                             1                             3                          2148                          2149                          2268                          2269
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2149                             1                             3                          2149                          2150                          2269                          2270
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2150                             1                             3                          2150                          2151                          2270                          2271
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2151                             1                             3                          2151                          2152                          2271                          2272
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2152                             1                             3                          2152                          2153                          2272                          2273
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2153                             1                             3                          2153                          2154                          2273                          2274
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2154                             1                             3                          2154                          2155                          2274                          2275
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2155                             1                             3                          2155                          2156                          2275                          2276
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2156                             1                             3                          2156                          2157                          2276                          2277
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2157                             1                             3                          2157                          2158                          2277                          2278
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2158                             1                             3                          2158                          2159                          2278                          2279
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2159                             1                             3                          2159                          2160                          2279                          2280
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2160                             1                             3                          2160                          2041                          2280                          2161
  0.2383768722227583292117E-01  0.2497836844596560551546E-01
                          2161                             1                             2                          2161                          2162                          2281                          2282
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2162                             1                             2                          2162                          2163                          2282                          2283
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2163                             1                             2                          2163                          2164                          2283                          2284
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2164                             1                             2                          2164                          2165                          2284                          2285
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2165                             1                             2                          2165                          2166                          2285                          2286
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2166                             1                             2                          2166                          2167                          2286                          2287
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2167                             1                             2                          2167                          2168                          2287                          2288
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2168                             1                             2                          2168                          2169                          2288                          2289
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2169                             1                             2                          2169                          2170                          2289                          2290
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2170                             1                             2                          2170                          2171                          2290                          2291
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2171                             1                             2                          2171                          2172                          2291                          2292
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2172                             1                             2                          2172                          2173                          2292                          2293
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2173                             1                             2                          2173                          2174                          2293                          2294
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2174                             1                             2                          2174                          2175                          2294                          2295
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2175                             1                             2                          2175                          2176                          2295                          2296
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2176                             1                             2                          2176                          2177                          2296                          2297
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2177                             1                             2                          2177                          2178                          2297                          2298
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2178                             1                             2                          2178                          2179                          2298                          2299
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2179                             1                             2                          2179                          2180                          2299                          2300
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2180                             1                             2                          2180                          2181                          2300                          2301
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2181                             1                             2                          2181                          2182                          2301                          2302
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2182                             1                             2                          2182                          2183                          2302                          2303
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2183                             1                             2                          2183                          2184                          2303                          2304
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2184                             1                             2                          2184                          2185                          2304                          2305
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2185                             1                             2                          2185                          2186                          2305                          2306
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2186                             1                             2                          2186                          2187                          2306                          2307
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2187                             1                             2                          2187                          2188                          2307                          2308
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2188                             1                             2                          2188                          2189                          2308                          2309
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2189                             1                             2                          2189                          2190                          2309                          2310
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2190                             1                             2                          2190                          2191                          2310                          2311
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2191                             1                             2                          2191                          2192                          2311                          2312
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2192                             1                             2                          2192                          2193                          2312                          2313
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2193                             1                             2                          2193                          2194                          2313                          2314
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2194                             1                             2                          2194                          2195                          2314                          2315
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2195                             1                             2                          2195                          2196                          2315                          2316
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2196                             1                             2                          2196                          2197                          2316                          2317
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2197                             1                             2                          2197                          2198                          2317                          2318
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2198                             1                             2                          2198                          2199                          2318                          2319
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2199                             1                             2                          2199                          2200                          2319                          2320
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2200                             1                             2                          2200                          2201                          2320                          2321
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2201                             1                             2                          2201                          2202                          2321                          2322
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
                          2202                             1                             2                          2202                          2203                          2322                          2323
  0.2293582323282267187992E-01  0.2778396458610110988929E-01
