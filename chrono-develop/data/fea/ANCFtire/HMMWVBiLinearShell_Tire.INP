 -0.3917822137689462858035E+00 -0.2087723167897392873016E-01  0.2128736554987162299390E+00  0.8386013694393711359609E+00  0.1284572727460347313366E-01  0.5445940969797579134237E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1423                             0                             0                             0                             0                             0                             0
 -0.3779296438283284431670E+00 -0.2087723167897392873016E-01  0.1927180411648007352099E+00  0.8089502425780894512286E+00  0.1284572727460347313366E-01  0.5877367542732347960310E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1424                             0                             0                             0                             0                             0                             0
 -0.3630411950035447588014E+00 -0.2087723167897392873016E-01  0.1733150368940948871099E+00  0.7770818393313436711622E+00  0.1284572727460346966422E-01  0.6292684659763290166978E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1425                             0                             0                             0                             0                             0                             0
 -0.3471576754979399659362E+00 -0.2087723167897392873016E-01  0.1547178249726173793199E+00  0.7430835087772859059996E+00  0.1284572727460347139894E-01  0.6690753965540983116966E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1426                             0                             0                             0                             0                             0                             0
 -0.3303226209344300445814E+00 -0.2087723167897392873016E-01  0.1369773790655700596020E+00  0.7070484379767721927479E+00  0.1284572727460347313366E-01  0.7070484379767719707033E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1427                             0                             0                             0                             0                             0                             0
 -0.3125821750273823917965E+00 -0.2087723167897392873016E-01  0.1201423245020598051802E+00  0.6690753965540978676074E+00  0.1284572727460347139894E-01  0.7430835087772863500888E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1428                             0                             0                             0                             0                             0                             0
 -0.2939849631059055501403E+00 -0.2087723167897392873016E-01  0.1042588049964555674265E+00  0.6292684659763300158986E+00  0.1284572727460347139894E-01  0.7770818393313428940061E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1429                             0                             0                             0                             0                             0                             0
 -0.2745819588351993689734E+00 -0.2087723167897392873016E-01  0.8937035617167166101638E-01  0.5877367542732350180756E+00  0.1284572727460346966422E-01  0.8089502425780892291840E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1430                             0                             0                             0                             0                             0                             0
 -0.2544263445012842073112E+00 -0.2087723167897392873016E-01  0.7551778623105404042448E-01  0.5445940969797589126244E+00  0.1284572727460346966422E-01  0.8386013694393704698271E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1431                             0                             0                             0                             0                             0                             0
 -0.2335733652420486639034E+00 -0.2087723167897392873016E-01  0.6273906410592883231558E-01  0.4999587451207311850077E+00  0.1284572727460347139894E-01  0.8659539482374858376801E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1432                             0                             0                             0                             0                             0                             0
 -0.2120801776241709457604E+00 -0.2087723167897392873016E-01  0.5106921538540387661698E-01  0.4539530410930353587773E+00  0.1284572727460347313366E-01  0.8909330074552022082912E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1433                             0                             0                             0                             0                             0                             0
 -0.1900056929809374461904E+00 -0.2087723167897392873016E-01  0.4054022631366016593546E-01  0.4067030833335918416083E+00  0.1284572727460347139894E-01  0.9134700812274784142986E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1434                             0                             0                             0                             0                             0                             0
 -0.1674104159403773106618E+00 -0.2087723167897392873016E-01  0.3118095611788274101883E-01  0.3583383806923163827918E+00  0.1284572727460347313366E-01  0.9335033970016366478006E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1435                             0                             0                             0                             0                             0                             0
 -0.1443562785862795572189E+00 -0.2087723167897392873016E-01  0.2301705790712299526390E-01  0.3089914974573578776429E+00  0.1284572727460347139894E-01  0.9509780448516391704317E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1436                             0                             0                             0                             0                             0                             0
 -0.1209064707066587335271E+00 -0.2087723167897392873016E-01  0.1607090835891122893031E-01  0.2587976900056044859966E+00  0.1284572727460346966422E-01  0.9658461279823766787445E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1437                             0                             0                             0                             0                             0                             0
 -0.9712526659493668501621E-01 -0.2087723167897392873016E-01  0.1036154638633807190118E-01  0.2078945360743525705427E+00  0.1284572727460346966422E-01  0.9780668940114557452503E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1438                             0                             0                             0                             0                             0                             0
 -0.7307784887857281252987E-01 -0.2087723167897392873016E-01  0.5904620953717520936976E-02  0.1564215576702937260389E+00  0.1284572727460346966422E-01  0.9876068466686455105119E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1439                             0                             0                             0                             0                             0                             0
 -0.4883012985801137018083E-01 -0.2087723167897392873016E-01  0.2712348183863122486059E-02  0.1045198386493889214366E+00  0.1284572727460347139894E-01  0.9944398376068269707062E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1440                             0                             0                             0                             0                             0                             0
 -0.2444857084565023666589E-01 -0.2087723167897392873016E-01  0.7934778745452009118821E-03  0.5233163801583190499755E-01  0.1284572727460347139894E-01  0.9985471380727934942456E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1441                             0                             0                             0                             0                             0                             0
  0.2861387246207790657258E-16  0.0000000000000000000000E+00  0.0000000000000000000000E+00 -0.6123233995736766035869E-16 -0.1774356679499909638051E-16  0.1000000000000000000000E+01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1442                             0                             0                             0                             0                             0                             0
  0.2445659235232771483437E-01  0.0000000000000000000000E+00  0.6404184091876596873760E-03 -0.5233595624294396647658E-01 -0.1774356679499909638051E-16  0.9986295347545738332329E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1443                             0                             0                             0                             0                             0                             0
  0.4884615088497445967164E-01  0.0000000000000000000000E+00  0.2559918294405882921438E-02 -0.1045284632676534569695E+00 -0.1774356679499909329902E-16  0.9945218953682732898613E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1444                             0                             0                             0                             0                             0                             0
  0.7310182551329991174072E-01  0.0000000000000000000000E+00  0.5753238439892116584673E-02 -0.1564344650402309244708E+00 -0.1774356679499909638051E-16  0.9876883405951377703502E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1445                             0                             0                             0                             0                             0                             0
  0.9715713311913899696837E-01  0.0000000000000000000000E+00  0.1021162617709264752719E-01 -0.2079116908177594535978E+00 -0.1774356679499909638051E-16  0.9781476007338055778106E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1446                             0                             0                             0                             0                             0                             0
  0.1209461397764079459982E+00  0.0000000000000000000000E+00  0.1592286137511839116954E-01 -0.2588190451025207394764E+00 -0.1774356679499909946200E-16  0.9659258262890683122137E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1447                             0                             0                             0                             0                             0                             0
  0.1444036414714129357151E+00  0.0000000000000000000000E+00  0.2287128993527476339409E-01 -0.3090169943749474512629E+00 -0.1774356679499909329902E-16  0.9510565162951535311819E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1448                             0                             0                             0                             0                             0                             0
  0.1674653428225188755984E+00  0.0000000000000000000000E+00  0.3103786669785763008278E-01 -0.3583679495453003793770E+00 -0.1774356679499909638051E-16  0.9335804264972017429969E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1449                             0                             0                             0                             0                             0                             0
  0.1900680333093214269269E+00  0.0000000000000000000000E+00  0.4040020764361262894937E-01 -0.4067366430758002082690E+00 -0.1774356679499909638051E-16  0.9135454576426008665990E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1450                             0                             0                             0                             0                             0                             0
  0.2121497605282902099155E+00  0.0000000000000000000000E+00  0.5093265124677570643286E-01 -0.4539904997395468044807E+00 -0.1774356679499909329902E-16  0.8910065241883677877865E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1451                             0                             0                             0                             0                             0                             0
  0.2336499999999999410694E+00  0.0000000000000000000000E+00  0.6260632881153177509148E-01 -0.4999999999999998889777E+00 -0.1774356679499909638051E-16  0.8660254037844387076106E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1452                             0                             0                             0                             0                             0                             0
  0.2545098210625221790693E+00  0.0000000000000000000000E+00  0.7538924359910331718382E-01 -0.5446390350150270842633E+00 -0.1774356679499909638051E-16  0.8386705679454240502935E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1453                             0                             0                             0                             0                             0                             0
  0.2746720483962726833127E+00  0.0000000000000000000000E+00  0.8924635852858703310986E-01 -0.5877852522924731371035E+00 -0.1774356679499909946200E-16  0.8090169943749474512629E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1454                             0                             0                             0                             0                             0                             0
  0.2940814187375890842446E+00  0.0000000000000000000000E+00  0.1041396922111575418235E+00 -0.6293203910498375019955E+00 -0.1774356679499909329902E-16  0.7771459614569707907705E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1455                             0                             0                             0                             0                             0                             0
  0.3126847323514944654299E+00  0.0000000000000000000000E+00  0.1200284230544137464847E+00 -0.6691306063588582375701E+00 -0.1774356679499909329902E-16  0.7431448254773941330953E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1456                             0                             0                             0                             0                             0                             0
  0.3304309988484736004821E+00  0.0000000000000000000000E+00  0.1368690011515263371678E+00 -0.7071067811865474617150E+00 -0.1774356679499909638051E-16  0.7071067811865475727373E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1457                             0                             0                             0                             0                             0                             0
  0.3472715769455863021875E+00  0.0000000000000000000000E+00  0.1546152676485055277311E+00 -0.7431448254773942441176E+00 -0.1774356679499909638051E-16  0.6691306063588582375701E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1458                             0                             0                             0                             0                             0                             0
  0.3631603077888425068487E+00  0.0000000000000000000000E+00  0.1732185812624109644275E+00 -0.7771459614569709017928E+00 -0.1774356679499909638051E-16  0.6293203910498373909732E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1459                             0                             0                             0                             0                             0                             0
  0.3780536414714129600512E+00  0.0000000000000000000000E+00  0.1926279516037273098483E+00 -0.8090169943749474512629E+00 -0.1774356679499909946200E-16  0.5877852522924731371035E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1460                             0                             0                             0                             0                             0                             0
  0.3919107564008966759772E+00  0.0000000000000000000000E+00  0.2127901789374778140917E+00 -0.8386705679454240502935E+00 -0.1774356679499909638051E-16  0.5446390350150270842633E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1461                             0                             0                             0                             0                             0                             0
  0.4046936711884681625584E+00  0.0000000000000000000000E+00  0.2336499999999999965805E+00 -0.8660254037844385965883E+00 -0.1774356679499909329902E-16  0.5000000000000000000000E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1462                             0                             0                             0                             0                             0                             0
  0.4163673487532242867282E+00  0.0000000000000000000000E+00  0.2551502394717097832455E+00 -0.8910065241883678988088E+00 -0.1774356679499909946200E-16  0.4539904997395467489696E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1463                             0                             0                             0                             0                             0                             0
  0.4268997923563873642117E+00  0.0000000000000000000000E+00  0.2772319666906785107230E+00 -0.9135454576426008665990E+00 -0.1774356679499909946200E-16  0.4067366430758003192913E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1464                             0                             0                             0                             0                             0                             0
  0.4362621333021423630782E+00  0.0000000000000000000000E+00  0.2998346571774811453182E+00 -0.9335804264972017429969E+00 -0.1774356679499909638051E-16  0.3583679495453003238659E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1465                             0                             0                             0                             0                             0                             0
  0.4444287100647252297669E+00  0.0000000000000000000000E+00  0.3228963585285871129571E+00 -0.9510565162951535311819E+00 -0.1774356679499909329902E-16  0.3090169943749473957517E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1466                             0                             0                             0                             0                             0                             0
  0.4513771386248816019915E+00  0.0000000000000000000000E+00  0.3463538602235920471628E+00 -0.9659258262890683122137E+00 -0.1774356679499909946200E-16  0.2588190451025206839653E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1467                             0                             0                             0                             0                             0                             0
  0.4570883738229074011450E+00  0.0000000000000000000000E+00  0.3701428668808611210927E+00 -0.9781476007338056888329E+00 -0.1774356679499909638051E-16  0.2079116908177591760420E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1468                             0                             0                             0                             0                             0                             0
  0.4615467615601078765764E+00  0.0000000000000000000000E+00  0.3941981744867001369315E+00 -0.9876883405951377703502E+00 -0.1774356679499909638051E-16  0.1564344650402308689596E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1469                             0                             0                             0                             0                             0                             0
  0.4647400817055941102396E+00  0.0000000000000000000000E+00  0.4184538491150255890005E+00 -0.9945218953682732898613E+00 -0.1774356679499909329902E-16  0.1045284632676533875806E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1470                             0                             0                             0                             0                             0                             0
  0.4666595815908123334737E+00  0.0000000000000000000000E+00  0.4428434076476723824101E+00 -0.9986295347545738332329E+00 -0.1774356679499909638051E-16  0.5233595624294368198193E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1471                             0                             0                             0                             0                             0                             0
  0.4672999999999999931610E+00  0.0000000000000000000000E+00  0.4672999999999998821387E+00 -0.1000000000000000000000E+01 -0.1774356679499909638051E-16  0.2220446049250313080847E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1472                             0                             0                             0                             0                             0                             0
  0.4666595815908123334737E+00  0.0000000000000000000000E+00  0.4917565923523276039120E+00 -0.9986295347545738332329E+00 -0.1774356679499909638051E-16 -0.5233595624294368198193E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1473                             0                             0                             0                             0                             0                             0
  0.4647400817055941102396E+00  0.0000000000000000000000E+00  0.5161461508849743973215E+00 -0.9945218953682732898613E+00 -0.1774356679499909329902E-16 -0.1045284632676533875806E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1474                             0                             0                             0                             0                             0                             0
  0.4615467615601078765764E+00  0.0000000000000000000000E+00  0.5404018255132998493906E+00 -0.9876883405951377703502E+00 -0.1774356679499909638051E-16 -0.1564344650402308689596E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1475                             0                             0                             0                             0                             0                             0
  0.4570883738229073456338E+00  0.0000000000000000000000E+00  0.5644571331191389207405E+00 -0.9781476007338055778106E+00 -0.1774356679499909638051E-16 -0.2079116908177593980867E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1476                             0                             0                             0                             0                             0                             0
  0.4513771386248816019915E+00  0.0000000000000000000000E+00  0.5882461397764079391592E+00 -0.9659258262890683122137E+00 -0.1774356679499909946200E-16 -0.2588190451025206839653E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1477                             0                             0                             0                             0                             0                             0
  0.4444287100647252297669E+00  0.0000000000000000000000E+00  0.6117036414714128733650E+00 -0.9510565162951535311819E+00 -0.1774356679499909329902E-16 -0.3090169943749473957517E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1478                             0                             0                             0                             0                             0                             0
  0.4362621333021423630782E+00  0.0000000000000000000000E+00  0.6347653428225188410039E+00 -0.9335804264972017429969E+00 -0.1774356679499909638051E-16 -0.3583679495453003238659E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1479                             0                             0                             0                             0                             0                             0
  0.4268997923563874197228E+00  0.0000000000000000000000E+00  0.6573680333093213645768E+00 -0.9135454576426009776213E+00 -0.1774356679499909946200E-16 -0.4067366430758001527579E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1480                             0                             0                             0                             0                             0                             0
  0.4163673487532242867282E+00  0.0000000000000000000000E+00  0.6794497605282902030766E+00 -0.8910065241883678988088E+00 -0.1774356679499909946200E-16 -0.4539904997395467489696E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1481                             0                             0                             0                             0                             0                             0
  0.4046936711884682180695E+00  0.0000000000000000000000E+00  0.7009499999999999619860E+00 -0.8660254037844387076106E+00 -0.1774356679499909638051E-16 -0.4999999999999998334665E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1482                             0                             0                             0                             0                             0                             0
  0.3919107564008967314884E+00  0.0000000000000000000000E+00  0.7218098210625221167192E+00 -0.8386705679454241613158E+00 -0.1774356679499909638051E-16 -0.5446390350150268622187E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1483                             0                             0                             0                             0                             0                             0
  0.3780536414714129600512E+00  0.0000000000000000000000E+00  0.7419720483962726209626E+00 -0.8090169943749474512629E+00 -0.1774356679499909946200E-16 -0.5877852522924731371035E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1484                             0                             0                             0                             0                             0                             0
  0.3631603077888425623598E+00  0.0000000000000000000000E+00  0.7613814187375889108722E+00 -0.7771459614569710128151E+00 -0.1774356679499909638051E-16 -0.6293203910498372799509E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1485                             0                             0                             0                             0                             0                             0
  0.3472715769455864132098E+00  0.0000000000000000000000E+00  0.7799847323514943475686E+00 -0.7431448254773944661622E+00 -0.1774356679499909946200E-16 -0.6691306063588580155255E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1486                             0                             0                             0                             0                             0                             0
  0.3304309988484736559933E+00  0.0000000000000000000000E+00  0.7977309988484735381320E+00 -0.7071067811865475727373E+00 -0.1774356679499909638051E-16 -0.7071067811865474617150E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1487                             0                             0                             0                             0                             0                             0
  0.3126847323514945209411E+00  0.0000000000000000000000E+00  0.8145715769455862398374E+00 -0.6691306063588583485924E+00 -0.1774356679499909946200E-16 -0.7431448254773941330953E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1488                             0                             0                             0                             0                             0                             0
  0.2940814187375890287335E+00  0.0000000000000000000000E+00  0.8304603077888425000097E+00 -0.6293203910498373909732E+00 -0.1774356679499909638051E-16 -0.7771459614569709017928E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1489                             0                             0                             0                             0                             0                             0
  0.2746720483962726833127E+00  0.0000000000000000000000E+00  0.8453536414714128977010E+00 -0.5877852522924731371035E+00 -0.1774356679499909946200E-16 -0.8090169943749474512629E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1490                             0                             0                             0                             0                             0                             0
  0.2545098210625221790693E+00  0.0000000000000000000000E+00  0.8592107564008966136271E+00 -0.5446390350150271952856E+00 -0.1774356679499909329902E-16 -0.8386705679454239392712E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1491                             0                             0                             0                             0                             0                             0
  0.2336499999999999410694E+00  0.0000000000000000000000E+00  0.8719936711884681557194E+00 -0.4999999999999998889777E+00 -0.1774356679499909638051E-16 -0.8660254037844387076106E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1492                             0                             0                             0                             0                             0                             0
  0.2121497605282902099155E+00  0.0000000000000000000000E+00  0.8836673487532242798892E+00 -0.4539904997395468044807E+00 -0.1774356679499909329902E-16 -0.8910065241883677877865E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1493                             0                             0                             0                             0                             0                             0
  0.1900680333093213436602E+00  0.0000000000000000000000E+00  0.8941997923563873573727E+00 -0.4067366430757999862244E+00 -0.1774356679499909638051E-16 -0.9135454576426009776213E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1494                             0                             0                             0                             0                             0                             0
  0.1674653428225187645761E+00  0.0000000000000000000000E+00  0.9035621333021424117504E+00 -0.3583679495453001573324E+00 -0.1774356679499909329902E-16 -0.9335804264972017429969E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1495                             0                             0                             0                             0                             0                             0
  0.1444036414714129357151E+00  0.0000000000000000000000E+00  0.9117287100647252229280E+00 -0.3090169943749474512629E+00 -0.1774356679499909329902E-16 -0.9510565162951535311819E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1496                             0                             0                             0                             0                             0                             0
  0.1209461397764078349759E+00  0.0000000000000000000000E+00  0.9186771386248815396414E+00 -0.2588190451025205174318E+00 -0.1774356679499909638051E-16 -0.9659258262890683122137E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1497                             0                             0                             0                             0                             0                             0
  0.9715713311913888594606E-01  0.0000000000000000000000E+00  0.9243883738229073943060E+00 -0.2079116908177592315532E+00 -0.1774356679499909638051E-16 -0.9781476007338056888329E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1498                             0                             0                             0                             0                             0                             0
  0.7310182551329991174072E-01  0.0000000000000000000000E+00  0.9288467615601079252485E+00 -0.1564344650402309244708E+00 -0.1774356679499909638051E-16 -0.9876883405951377703502E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1499                             0                             0                             0                             0                             0                             0
  0.4884615088497435558823E-01  0.0000000000000000000000E+00  0.9320400817055941589118E+00 -0.1045284632676532349249E+00 -0.1774356679499909946200E-16 -0.9945218953682734008837E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1500                             0                             0                             0                             0                             0                             0
  0.2445659235232761075096E-01  0.0000000000000000000000E+00  0.9339595815908123821458E+00 -0.5233595624294374443197E-01 -0.1774356679499909638051E-16 -0.9986295347545738332329E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1501                             0                             0                             0                             0                             0                             0
  0.2361367602250121887234E-15  0.0000000000000000000000E+00  0.9345999999999999863221E+00 -0.5053215498074302888541E-15 -0.1774356679499909638051E-16 -0.1000000000000000000000E+01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1502                             0                             0                             0                             0                             0                             0
 -0.2445659235232755177036E-01  0.0000000000000000000000E+00  0.9339595815908123821458E+00  0.5233595624294361953188E-01 -0.1774356679499909638051E-16 -0.9986295347545738332329E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1503                             0                             0                             0                             0                             0                             0
 -0.4884615088497430007708E-01  0.0000000000000000000000E+00  0.9320400817055941589118E+00  0.1045284632676531100248E+00 -0.1774356679499909946200E-16 -0.9945218953682734008837E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1504                             0                             0                             0                             0                             0                             0
 -0.7310182551329985622957E-01  0.0000000000000000000000E+00  0.9288467615601079252485E+00  0.1564344650402308134485E+00 -0.1774356679499909638051E-16 -0.9876883405951377703502E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1505                             0                             0                             0                             0                             0                             0
 -0.9715713311913883043491E-01  0.0000000000000000000000E+00  0.9243883738229073943060E+00  0.2079116908177591205309E+00 -0.1774356679499909329902E-16 -0.9781476007338056888329E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1506                             0                             0                             0                             0                             0                             0
 -0.1209461397764077794648E+00  0.0000000000000000000000E+00  0.9186771386248816506637E+00  0.2588190451025204064095E+00 -0.1774356679499909946200E-16 -0.9659258262890684232360E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1507                             0                             0                             0                             0                             0                             0
 -0.1444036414714128802039E+00  0.0000000000000000000000E+00  0.9117287100647253339503E+00  0.3090169943749473402406E+00 -0.1774356679499909946200E-16 -0.9510565162951536422042E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1508                             0                             0                             0                             0                             0                             0
 -0.1674653428225187090650E+00  0.0000000000000000000000E+00  0.9035621333021424117504E+00  0.3583679495453000463101E+00 -0.1774356679499909946200E-16 -0.9335804264972018540192E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1509                             0                             0                             0                             0                             0                             0
 -0.1900680333093214546825E+00  0.0000000000000000000000E+00  0.8941997923563873573727E+00  0.4067366430758002637802E+00 -0.1774356679499909638051E-16 -0.9135454576426008665990E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1510                             0                             0                             0                             0                             0                             0
 -0.2121497605282901544044E+00  0.0000000000000000000000E+00  0.8836673487532242798892E+00  0.4539904997395466934584E+00 -0.1774356679499909638051E-16 -0.8910065241883678988088E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1511                             0                             0                             0                             0                             0                             0
 -0.2336499999999998855582E+00  0.0000000000000000000000E+00  0.8719936711884681557194E+00  0.4999999999999997779554E+00 -0.1774356679499909329902E-16 -0.8660254037844387076106E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1512                             0                             0                             0                             0                             0                             0
 -0.2545098210625221790693E+00  0.0000000000000000000000E+00  0.8592107564008966136271E+00  0.5446390350150270842633E+00 -0.1774356679499909329902E-16 -0.8386705679454239392712E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1513                             0                             0                             0                             0                             0                             0
 -0.2746720483962726278016E+00  0.0000000000000000000000E+00  0.8453536414714128977010E+00  0.5877852522924730260812E+00 -0.1774356679499909638051E-16 -0.8090169943749474512629E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1514                             0                             0                             0                             0                             0                             0
 -0.2940814187375889732223E+00  0.0000000000000000000000E+00  0.8304603077888426110320E+00  0.6293203910498372799509E+00 -0.1774356679499909638051E-16 -0.7771459614569710128151E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1515                             0                             0                             0                             0                             0                             0
 -0.3126847323514944654299E+00  0.0000000000000000000000E+00  0.8145715769455863508597E+00  0.6691306063588582375701E+00 -0.1774356679499909638051E-16 -0.7431448254773942441176E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1516                             0                             0                             0                             0                             0                             0
 -0.3304309988484736004821E+00  0.0000000000000000000000E+00  0.7977309988484736491543E+00  0.7071067811865474617150E+00 -0.1774356679499909638051E-16 -0.7071067811865475727373E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1517                             0                             0                             0                             0                             0                             0
 -0.3472715769455862466764E+00  0.0000000000000000000000E+00  0.7799847323514945696132E+00  0.7431448254773940220730E+00 -0.1774356679499909329902E-16 -0.6691306063588583485924E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1518                             0                             0                             0                             0                             0                             0
 -0.3631603077888423958264E+00  0.0000000000000000000000E+00  0.7613814187375891329168E+00  0.7771459614569706797482E+00 -0.1774356679499909946200E-16 -0.6293203910498377240401E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1519                             0                             0                             0                             0                             0                             0
 -0.3780536414714129045400E+00  0.0000000000000000000000E+00  0.7419720483962727319849E+00  0.8090169943749473402406E+00 -0.1774356679499909638051E-16 -0.5877852522924732481258E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1520                             0                             0                             0                             0                             0                             0
 -0.3919107564008967314884E+00  0.0000000000000000000000E+00  0.7218098210625221167192E+00  0.8386705679454241613158E+00 -0.1774356679499909946200E-16 -0.5446390350150269732410E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1521                             0                             0                             0                             0                             0                             0
 -0.4046936711884681070472E+00  0.0000000000000000000000E+00  0.7009500000000001840306E+00  0.8660254037844384855660E+00 -0.1774356679499909946200E-16 -0.5000000000000003330669E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1522                             0                             0                             0                             0                             0                             0
 -0.4163673487532242867282E+00  0.0000000000000000000000E+00  0.6794497605282902030766E+00  0.8910065241883677877865E+00 -0.1774356679499909329902E-16 -0.4539904997395468599919E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1523                             0                             0                             0                             0                             0                             0
 -0.4268997923563872531894E+00  0.0000000000000000000000E+00  0.6573680333093216976437E+00  0.9135454576426006445544E+00 -0.1774356679499909946200E-16 -0.4067366430758008188917E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1524                             0                             0                             0                             0                             0                             0
 -0.4362621333021424741005E+00  0.0000000000000000000000E+00  0.6347653428225186189593E+00  0.9335804264972019650415E+00 -0.1774356679499909638051E-16 -0.3583679495452998242655E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1525                             0                             0                             0                             0                             0                             0
 -0.4444287100647252297669E+00  0.0000000000000000000000E+00  0.6117036414714129843873E+00  0.9510565162951535311819E+00 -0.1774356679499909329902E-16 -0.3090169943749475067740E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1526                             0                             0                             0                             0                             0                             0
 -0.4513771386248816019915E+00  0.0000000000000000000000E+00  0.5882461397764078281369E+00  0.9659258262890683122137E+00 -0.1774356679499909638051E-16 -0.2588190451025205729430E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1527                             0                             0                             0                             0                             0                             0
 -0.4570883738229073456338E+00  0.0000000000000000000000E+00  0.5644571331191391427851E+00  0.9781476007338055778106E+00 -0.1774356679499909946200E-16 -0.2079116908177597311536E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1528                             0                             0                             0                             0                             0                             0
 -0.4615467615601078210652E+00  0.0000000000000000000000E+00  0.5404018255132999604129E+00  0.9876883405951376593279E+00 -0.1774356679499909329902E-16 -0.1564344650402309799819E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1529                             0                             0                             0                             0                             0                             0
 -0.4647400817055941102396E+00  0.0000000000000000000000E+00  0.5161461508849748414107E+00  0.9945218953682732898613E+00 -0.1774356679499909638051E-16 -0.1045284632676541786145E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1530                             0                             0                             0                             0                             0                             0
 -0.4666595815908123889848E+00  0.0000000000000000000000E+00  0.4917565923523274373785E+00  0.9986295347545739442552E+00 -0.1774356679499909946200E-16 -0.5233595624294336279281E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1531                             0                             0                             0                             0                             0                             0
 -0.4672999999999999931610E+00  0.0000000000000000000000E+00  0.4673000000000000486722E+00  0.1000000000000000000000E+01 -0.1774356679499909638051E-16 -0.1224646799147353207174E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1532                             0                             0                             0                             0                             0                             0
 -0.4666595815908123334737E+00  0.0000000000000000000000E+00  0.4428434076476722713878E+00  0.9986295347545738332329E+00 -0.1774356679499909638051E-16  0.5233595624294400117105E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1533                             0                             0                             0                             0                             0                             0
 -0.4647400817055941657507E+00  0.0000000000000000000000E+00  0.4184538491150257000228E+00  0.9945218953682734008837E+00 -0.1774356679499909946200E-16  0.1045284632676530545137E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1534                             0                             0                             0                             0                             0                             0
 -0.4615467615601078765764E+00  0.0000000000000000000000E+00  0.3941981744867001924426E+00  0.9876883405951377703502E+00 -0.1774356679499909638051E-16  0.1564344650402307301817E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1535                             0                             0                             0                             0                             0                             0
 -0.4570883738229073456338E+00  0.0000000000000000000000E+00  0.3701428668808609545593E+00  0.9781476007338055778106E+00 -0.1774356679499909638051E-16  0.2079116908177595091090E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1536                             0                             0                             0                             0                             0                             0
 -0.4513771386248815464803E+00  0.0000000000000000000000E+00  0.3463538602235918251182E+00  0.9659258262890682011914E+00 -0.1774356679499909638051E-16  0.2588190451025211835656E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1537                             0                             0                             0                             0                             0                             0
 -0.4444287100647252852781E+00  0.0000000000000000000000E+00  0.3228963585285871129571E+00  0.9510565162951536422042E+00 -0.1774356679499909946200E-16  0.3090169943749472847294E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1538                             0                             0                             0                             0                             0                             0
 -0.4362621333021424741005E+00  0.0000000000000000000000E+00  0.2998346571774814783851E+00  0.9335804264972019650415E+00 -0.1774356679499909329902E-16  0.3583679495452996022209E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1539                             0                             0                             0                             0                             0                             0
 -0.4268997923563874752340E+00  0.0000000000000000000000E+00  0.2772319666906787327676E+00  0.9135454576426010886436E+00 -0.1774356679499909638051E-16  0.4067366430757998196910E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1540                             0                             0                             0                             0                             0                             0
 -0.4163673487532242867282E+00  0.0000000000000000000000E+00  0.2551502394717098387567E+00  0.8910065241883678988088E+00 -0.1774356679499909638051E-16  0.4539904997395466934584E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1541                             0                             0                             0                             0                             0                             0
 -0.4046936711884681625584E+00  0.0000000000000000000000E+00  0.2336499999999999410694E+00  0.8660254037844385965883E+00 -0.1774356679499909638051E-16  0.5000000000000001110223E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1542                             0                             0                             0                             0                             0                             0
 -0.3919107564008967314884E+00  0.0000000000000000000000E+00  0.2127901789374779806252E+00  0.8386705679454242723381E+00 -0.1774356679499909638051E-16  0.5446390350150267511964E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1543                             0                             0                             0                             0                             0                             0
 -0.3780536414714130155623E+00  0.0000000000000000000000E+00  0.1926279516037273653595E+00  0.8090169943749475622852E+00 -0.1774356679499909638051E-16  0.5877852522924730260812E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1544                             0                             0                             0                             0                             0                             0
 -0.3631603077888427288933E+00  0.0000000000000000000000E+00  0.1732185812624112419833E+00  0.7771459614569713458820E+00 -0.1774356679499909329902E-16  0.6293203910498368358617E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1545                             0                             0                             0                             0                             0                             0
 -0.3472715769455861911652E+00  0.0000000000000000000000E+00  0.1546152676485053611977E+00  0.7431448254773939110507E+00 -0.1774356679499909638051E-16  0.6691306063588585706370E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1546                             0                             0                             0                             0                             0                             0
 -0.3304309988484737115044E+00  0.0000000000000000000000E+00  0.1368690011515263926789E+00  0.7071067811865476837596E+00 -0.1774356679499909946200E-16  0.7071067811865474617150E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1547                             0                             0                             0                             0                             0                             0
 -0.3126847323514944099188E+00  0.0000000000000000000000E+00  0.1200284230544136354624E+00  0.6691306063588581265478E+00 -0.1774356679499909638051E-16  0.7431448254773943551399E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1548                             0                             0                             0                             0                             0                             0
 -0.2940814187375891952669E+00  0.0000000000000000000000E+00  0.1041396922111576528458E+00  0.6293203910498378350624E+00 -0.1774356679499909638051E-16  0.7771459614569705687259E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1549                             0                             0                             0                             0                             0                             0
 -0.2746720483962727388239E+00  0.0000000000000000000000E+00  0.8924635852858708862101E-01  0.5877852522924732481258E+00 -0.1774356679499909638051E-16  0.8090169943749473402406E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1550                             0                             0                             0                             0                             0                             0
 -0.2545098210625224566250E+00  0.0000000000000000000000E+00  0.7538924359910353922842E-01  0.5446390350150277503971E+00 -0.1774356679499909638051E-16  0.8386705679454236062043E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1551                             0                             0                             0                             0                             0                             0
 -0.2336499999999998022915E+00  0.0000000000000000000000E+00  0.6260632881153171958033E-01  0.4999999999999996114219E+00 -0.1774356679499909329902E-16  0.8660254037844388186329E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1552                             0                             0                             0                             0                             0                             0
 -0.2121497605282902654267E+00  0.0000000000000000000000E+00  0.5093265124677570643286E-01  0.4539904997395469155030E+00 -0.1774356679499909329902E-16  0.8910065241883677877865E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1553                             0                             0                             0                             0                             0                             0
 -0.1900680333093213714157E+00  0.0000000000000000000000E+00  0.4040020764361257343822E-01  0.4067366430758000972467E+00 -0.1774356679499909946200E-16  0.9135454576426009776213E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1554                             0                             0                             0                             0                             0                             0
 -0.1674653428225190143763E+00  0.0000000000000000000000E+00  0.3103786669785768559393E-01  0.3583679495453007124439E+00 -0.1774356679499909638051E-16  0.9335804264972016319746E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1555                             0                             0                             0                             0                             0                             0
 -0.1444036414714129912262E+00  0.0000000000000000000000E+00  0.2287128993527476339409E-01  0.3090169943749475622852E+00 -0.1774356679499909638051E-16  0.9510565162951535311819E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1556                             0                             0                             0                             0                             0                             0
 -0.1209461397764078904871E+00  0.0000000000000000000000E+00  0.1592286137511839116954E-01  0.2588190451025206284541E+00 -0.1774356679499909638051E-16  0.9659258262890683122137E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1557                             0                             0                             0                             0                             0                             0
 -0.9715713311913874716819E-01  0.0000000000000000000000E+00  0.1021162617709259201604E-01  0.2079116908177589262419E+00 -0.1774356679499909329902E-16  0.9781476007338056888329E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1558                             0                             0                             0                             0                             0                             0
 -0.7310182551329996725187E-01  0.0000000000000000000000E+00  0.5753238439892172095824E-02  0.1564344650402310354931E+00 -0.1774356679499909638051E-16  0.9876883405951376593279E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1559                             0                             0                             0                             0                             0                             0
 -0.4884615088497441109938E-01  0.0000000000000000000000E+00  0.2559918294405827410287E-02  0.1045284632676533598250E+00 -0.1774356679499909946200E-16  0.9945218953682734008837E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1560                             0                             0                             0                             0                             0                             0
 -0.2445659235232787442893E-01  0.0000000000000000000000E+00  0.6404184091876596873760E-03  0.5233595624294430648238E-01 -0.1774356679499909638051E-16  0.9986295347545738332329E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1561                             0                             0                             0                             0                             0                             0
  0.2860448741097507908179E-16  0.2087723167897390097458E-01  0.1532695159022767761314E-03 -0.6122728769178313627970E-16 -0.1284572727460344884753E-01  0.9999174902414631471714E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1562                             0                             0                             0                             0                             0                             0
  0.2444857084565007707133E-01  0.2087723167897390097458E-01  0.7934778745452009118821E-03 -0.5233163801583156499175E-01 -0.1284572727460344884753E-01  0.9985471380727934942456E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1563                             0                             0                             0                             0                             0                             0
  0.4883012985801141875308E-01  0.2087723167897390097458E-01  0.2712348183863177997210E-02 -0.1045198386493890185811E+00 -0.1284572727460344711281E-01  0.9944398376068268596839E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1564                             0                             0                             0                             0                             0                             0
  0.7307784887857275701872E-01  0.2087723167897390097458E-01  0.5904620953717465425825E-02 -0.1564215576702936150166E+00 -0.1284572727460344884753E-01  0.9876068466686456215342E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1565                             0                             0                             0                             0                             0                             0
  0.9712526659493693481640E-01  0.2087723167897390097458E-01  0.1036154638633807190118E-01 -0.2078945360743530978986E+00 -0.1284572727460344711281E-01  0.9780668940114556342280E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1566                             0                             0                             0                             0                             0                             0
  0.1209064707066587890383E+00  0.2087723167897390097458E-01  0.1607090835891122893031E-01 -0.2587976900056045970189E+00 -0.1284572727460345058226E-01  0.9658461279823766787445E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1567                             0                             0                             0                             0                             0                             0
  0.1443562785862795294634E+00  0.2087723167897390097458E-01  0.2301705790712299526390E-01 -0.3089914974573577666206E+00 -0.1284572727460344884753E-01  0.9509780448516391704317E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1568                             0                             0                             0                             0                             0                             0
  0.1674104159403771718839E+00  0.2087723167897390097458E-01  0.3118095611788268550768E-01 -0.3583383806923160497249E+00 -0.1284572727460344884753E-01  0.9335033970016367588229E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1569                             0                             0                             0                             0                             0                             0
  0.1900056929809375017015E+00  0.2087723167897390097458E-01  0.4054022631366022144661E-01 -0.4067030833335919526306E+00 -0.1284572727460344884753E-01  0.9134700812274783032763E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1570                             0                             0                             0                             0                             0                             0
  0.2120801776241709180049E+00  0.2087723167897390097458E-01  0.5106921538540387661698E-01 -0.4539530410930352477550E+00 -0.1284572727460344711281E-01  0.8909330074552022082912E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1571                             0                             0                             0                             0                             0                             0
  0.2335733652420488026813E+00  0.2087723167897390097458E-01  0.6273906410592888782674E-01 -0.4999587451207314625634E+00 -0.1284572727460344884753E-01  0.8659539482374857266578E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1572                             0                             0                             0                             0                             0                             0
  0.2544263445012839297554E+00  0.2087723167897390097458E-01  0.7551778623105381837988E-01 -0.5445940969797582464906E+00 -0.1284572727460344884753E-01  0.8386013694393709139163E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1573                             0                             0                             0                             0                             0                             0
  0.2745819588351993134623E+00  0.2087723167897390097458E-01  0.8937035617167160550522E-01 -0.5877367542732349070533E+00 -0.1284572727460344884753E-01  0.8089502425780893402063E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1574                             0                             0                             0                             0                             0                             0
  0.2939849631059054391180E+00  0.2087723167897390097458E-01  0.1042588049964554564042E+00 -0.6292684659763296828316E+00 -0.1284572727460344884753E-01  0.7770818393313431160507E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1575                             0                             0                             0                             0                             0                             0
  0.3125821750273824473076E+00  0.2087723167897390097458E-01  0.1201423245020599162025E+00 -0.6690753965540979786297E+00 -0.1284572727460344711281E-01  0.7430835087772861280442E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1576                             0                             0                             0                             0                             0                             0
  0.3303226209344299335591E+00  0.2087723167897390097458E-01  0.1369773790655700040908E+00 -0.7070484379767719707033E+00 -0.1284572727460344884753E-01  0.7070484379767720817256E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1577                             0                             0                             0                             0                             0                             0
  0.3471576754979401324697E+00  0.2087723167897390097458E-01  0.1547178249726175458534E+00 -0.7430835087772862390665E+00 -0.1284572727460344884753E-01  0.6690753965540979786297E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1578                             0                             0                             0                             0                             0                             0
  0.3630411950035445922680E+00  0.2087723167897390097458E-01  0.1733150368940946095542E+00 -0.7770818393313432270730E+00 -0.1284572727460344711281E-01  0.6292684659763295718093E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1579                             0                             0                             0                             0                             0                             0
  0.3779296438283283876558E+00  0.2087723167897390097458E-01  0.1927180411648006796987E+00 -0.8089502425780893402063E+00 -0.1284572727460344884753E-01  0.5877367542732349070533E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1580                             0                             0                             0                             0                             0                             0
  0.3917822137689461747811E+00  0.2087723167897390097458E-01  0.2128736554987160634056E+00 -0.8386013694393709139163E+00 -0.1284572727460344884753E-01  0.5445940969797582464906E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1581                             0                             0                             0                             0                             0                             0
  0.4045609358940710498231E+00  0.2087723167897390097458E-01  0.2337266347579511349686E+00 -0.8659539482374856156355E+00 -0.1284572727460344884753E-01  0.4999587451207315735857E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1582                             0                             0                             0                             0                             0                             0
  0.4162307846145961720552E+00  0.2087723167897390097458E-01  0.2552198223758290751562E+00 -0.8909330074552023193135E+00 -0.1284572727460344884753E-01  0.4539530410930351922438E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1583                             0                             0                             0                             0                             0                             0
  0.4267597736863397717144E+00  0.2087723167897390097458E-01  0.2772943070190624359483E+00 -0.9134700812274783032763E+00 -0.1284572727460344884753E-01  0.4067030833335920636529E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1584                             0                             0                             0                             0                             0                             0
  0.4361190438821173076533E+00  0.2087723167897390097458E-01  0.2998895840596228490327E+00 -0.9335033970016367588229E+00 -0.1284572727460344884753E-01  0.3583383806923159942137E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1585                             0                             0                             0                             0                             0                             0
  0.4442829420928769978971E+00  0.2087723167897390097458E-01  0.3229437214137205192088E+00 -0.9509780448516391704317E+00 -0.1284572727460344884753E-01  0.3089914974573577111094E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1586                             0                             0                             0                             0                             0                             0
  0.4512290916410887642307E+00  0.2087723167897390097458E-01  0.3463935292933412180005E+00 -0.9658461279823766787445E+00 -0.1284572727460344884753E-01  0.2587976900056045415077E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1587                             0                             0                             0                             0                             0                             0
  0.4569384536136619212598E+00  0.2087723167897390097458E-01  0.3701747334050631832447E+00 -0.9780668940114557452503E+00 -0.1284572727460345058226E-01  0.2078945360743528203429E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1588                             0                             0                             0                             0                             0                             0
  0.4613953790462825277352E+00  0.2087723167897390097458E-01  0.3942221511214272777757E+00 -0.9876068466686456215342E+00 -0.1284572727460344884753E-01  0.1564215576702935595055E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1589                             0                             0                             0                             0                             0                             0
  0.4645876518161368151638E+00  0.2087723167897390097458E-01  0.4184698701419886091024E+00 -0.9944398376068268596839E+00 -0.1284572727460344711281E-01  0.1045198386493889491922E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1590                             0                             0                             0                             0                             0                             0
  0.4665065221254547922491E+00  0.2087723167897390097458E-01  0.4428514291543500513981E+00 -0.9985471380727934942456E+00 -0.1284572727460344884753E-01  0.5233163801583128049710E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1591                             0                             0                             0                             0                             0                             0
  0.4671467304840977163849E+00  0.2087723167897390097458E-01  0.4672999999999998821387E+00 -0.9999174902414631471714E+00 -0.1284572727460344884753E-01  0.2220262840782945328691E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1592                             0                             0                             0                             0                             0                             0
  0.4665065221254547922491E+00  0.2087723167897390097458E-01  0.4917485708456499349239E+00 -0.9985471380727934942456E+00 -0.1284572727460344884753E-01 -0.5233163801583128049710E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1593                             0                             0                             0                             0                             0                             0
  0.4645876518161368151638E+00  0.2087723167897390097458E-01  0.5161301298580114327308E+00 -0.9944398376068268596839E+00 -0.1284572727460344711281E-01 -0.1045198386493889491922E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1594                             0                             0                             0                             0                             0                             0
  0.4613953790462825277352E+00  0.2087723167897390097458E-01  0.5403778488785727640575E+00 -0.9876068466686456215342E+00 -0.1284572727460344884753E-01 -0.1564215576702935595055E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1595                             0                             0                             0                             0                             0                             0
  0.4569384536136619212598E+00  0.2087723167897390097458E-01  0.5644252665949368585885E+00 -0.9780668940114556342280E+00 -0.1284572727460344711281E-01 -0.2078945360743530423875E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1596                             0                             0                             0                             0                             0                             0
  0.4512290916410887642307E+00  0.2087723167897390097458E-01  0.5882064707066587683215E+00 -0.9658461279823766787445E+00 -0.1284572727460344884753E-01 -0.2587976900056045415077E+00
