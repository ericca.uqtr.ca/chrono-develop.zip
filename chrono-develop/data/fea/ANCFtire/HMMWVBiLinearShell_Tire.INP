                           725                             0                             0                             0                             0                             0                             0
  0.9322732949311751671218E-01 -0.1252491859380352179354E+00  0.2869989864041083693635E-01 -0.1567036777784036050143E+00  0.6572151062641361507488E+00  0.7372328407422868989940E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           726                             0                             0                             0                             0                             0                             0
  0.1160541203910294416612E+00 -0.1252491859380352179354E+00  0.3418012627296279637434E-01 -0.1950727065281272487596E+00  0.6572151062641362617711E+00  0.7280212519329439802007E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           727                             0                             0                             0                             0                             0                             0
  0.1385628150117726442581E+00 -0.1252491859380352179354E+00  0.4084750537360737343562E-01 -0.2329070545485950327613E+00  0.6572151062641362617711E+00  0.7168142074761895132795E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           728                             0                             0                             0                             0                             0                             0
  0.1606917185879517540048E+00 -0.1252491859380352179354E+00  0.4868376111967331887342E-01 -0.2701030205217159751996E+00  0.6572151062641362617711E+00  0.7036424251018875697383E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           729                             0                             0                             0                             0                             0                             0
  0.1823801773330256115191E+00 -0.1252491859380352179354E+00  0.5766741487885229666688E-01 -0.3065586528902175533773E+00  0.6572151062641362617711E+00  0.6885420077499665447718E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           730                             0                             0                             0                             0                             0                             0
  0.2035687446891203955524E+00 -0.1252491859380352179354E+00  0.6777384308063649775988E-01 -0.3421740292997778043471E+00  0.6572151062641362617711E+00  0.6715543446147710371363E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           731                             0                             0                             0                             0                             0                             0
  0.2241993442659122037774E+00 -0.1252491859380352179354E+00  0.7897534470781392146321E-01 -0.3768515304792524056587E+00  0.6572151062641362617711E+00  0.6527259977001567126109E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           732                             0                             0                             0                             0                             0                             0
  0.2442154290239766101234E+00 -0.1252491859380352179354E+00  0.9124121722303141224231E-01 -0.4104961078083123049431E+00  0.6572151062641362617711E+00  0.6321085741962739756872E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           733                             0                             0                             0                             0                             0                             0
  0.2635621362662925459830E+00 -0.1252491859380352179354E+00  0.1045378407223150896144E+00 -0.4430155438391041311519E+00  0.6572151062641362617711E+00  0.6097585850278475216868E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           734                             0                             0                             0                             0                             0                             0
  0.2821864380130820748604E+00 -0.1252491859380352179354E+00  0.1188287700848904560047E+00 -0.4743207050578658878770E+00  0.6572151062641362617711E+00  0.5857372899616593020511E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           735                             0                             0                             0                             0                             0                             0
  0.3000372863478165674778E+00 -0.1252491859380352179354E+00  0.1340748348667248346366E+00 -0.5043257861936919494994E+00  0.6572151062641361507488E+00  0.5601105296977859637764E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           736                             0                             0                             0                             0                             0                             0
  0.3170657533360076718587E+00 -0.1252491859380352179354E+00  0.1502342466639922657912E+00 -0.5329485454048166204188E+00  0.6572151062641362617711E+00  0.5329485454048167314411E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           737                             0                             0                             0                             0                             0                             0
  0.3332251651332752140355E+00 -0.1252491859380352179354E+00  0.1672627136521834256833E+00 -0.5601105296977860747987E+00  0.6572151062641362617711E+00  0.5043257861936919494994E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           738                             0                             0                             0                             0                             0                             0
  0.3484712299151095926675E+00 -0.1252491859380352179354E+00  0.1851135619869179738117E+00 -0.5857372899616593020511E+00  0.6572151062641362617711E+00  0.4743207050578658323658E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           739                             0                             0                             0                             0                             0                             0
  0.3627621592776849035467E+00 -0.1252491859380352179354E+00  0.2037378637337074471780E+00 -0.6097585850278475216868E+00  0.6572151062641362617711E+00  0.4430155438391041311519E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           740                             0                             0                             0                             0                             0                             0
  0.3760587827769685809187E+00 -0.1252491859380352179354E+00  0.2230845709760233830377E+00 -0.6321085741962739756872E+00  0.6572151062641362617711E+00  0.4104961078083123049431E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           741                             0                             0                             0                             0                             0                             0
  0.3883246552921860716978E+00 -0.1252491859380352179354E+00  0.2431006557340877338724E+00 -0.6527259977001567126109E+00  0.6572151062641362617711E+00  0.3768515304792525166810E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           742                             0                             0                             0                             0                             0                             0
  0.3995261569193635509123E+00 -0.1252491859380352179354E+00  0.2637312553108795976087E+00 -0.6715543446147711481586E+00  0.6572151062641362617711E+00  0.3421740292997777488360E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           743                             0                             0                             0                             0                             0                             0
  0.4096325851211476964941E+00 -0.1252491859380352179354E+00  0.2849198226669743538864E+00 -0.6885420077499665447718E+00  0.6572151062641362617711E+00  0.3065586528902176088884E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           744                             0                             0                             0                             0                             0                             0
  0.4186162388803266742876E+00 -0.1252491859380352179354E+00  0.3066082814120482669118E+00 -0.7036424251018875697383E+00  0.6572151062641362617711E+00  0.2701030205217159196884E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           745                             0                             0                             0                             0                             0                             0
  0.4264524946263926197254E+00 -0.1252491859380352179354E+00  0.3287371849882273489030E+00 -0.7168142074761895132795E+00  0.6572151062641362617711E+00  0.2329070545485949772502E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           746                             0                             0                             0                             0                             0                             0
  0.4331198737270371967867E+00 -0.1252491859380352179354E+00  0.3512458796089705792554E+00 -0.7280212519329439802007E+00  0.6572151062641362617711E+00  0.1950727065281272210040E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           747                             0                             0                             0                             0                             0                             0
  0.4386001013595892117358E+00 -0.1252491859380352179354E+00  0.3740726705068825874712E+00 -0.7372328407422870100163E+00  0.6572151062641362617711E+00  0.1567036777784033829697E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           748                             0                             0                             0                             0                             0                             0
  0.4428781566010338011097E+00 -0.1252491859380352179354E+00  0.3971549910347829115409E+00 -0.7444237255795818075654E+00  0.6572151062641362617711E+00  0.1179051351402282538094E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           749                             0                             0                             0                             0                             0                             0
  0.4459423135993181297465E+00 -0.1252491859380352179354E+00  0.4204295741565372002135E+00 -0.7495741967293216845292E+00  0.6572151062641362617711E+00  0.7878342272211900920720E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           750                             0                             0                             0                             0                             0                             0
  0.4477841737130969779201E+00 -0.1252491859380352179354E+00  0.4438326258576050786786E+00 -0.7526701371080900537791E+00  0.6572151062641361507488E+00  0.3944577041849703369358E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           751                             0                             0                             0                             0                             0                             0
  0.4483986885318245185772E+00 -0.1252491859380352179354E+00  0.4672999999999998821387E+00 -0.7537030609585050333621E+00  0.6572151062641362617711E+00  0.1673556984013180389508E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           752                             0                             0                             0                             0                             0                             0
  0.4477841737130969779201E+00 -0.1252491859380352179354E+00  0.4907673741423949076434E+00 -0.7526701371080900537791E+00  0.6572151062641361507488E+00 -0.3944577041849703369358E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           753                             0                             0                             0                             0                             0                             0
  0.4459423135993181297465E+00 -0.1252491859380352179354E+00  0.5141704258434627305974E+00 -0.7495741967293216845292E+00  0.6572151062641362617711E+00 -0.7878342272211900920720E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           754                             0                             0                             0                             0                             0                             0
  0.4428781566010338011097E+00 -0.1252491859380352179354E+00  0.5374450089652170747812E+00 -0.7444237255795818075654E+00  0.6572151062641362617711E+00 -0.1179051351402282538094E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           755                             0                             0                             0                             0                             0                             0
  0.4386001013595891562247E+00 -0.1252491859380352179354E+00  0.5605273294931174543621E+00 -0.7372328407422868989940E+00  0.6572151062641361507488E+00 -0.1567036777784035495031E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           756                             0                             0                             0                             0                             0                             0
  0.4331198737270371967867E+00 -0.1252491859380352179354E+00  0.5833541203910294070667E+00 -0.7280212519329439802007E+00  0.6572151062641362617711E+00 -0.1950727065281272210040E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           757                             0                             0                             0                             0                             0                             0
  0.4264524946263926197254E+00 -0.1252491859380352179354E+00  0.6058628150117726374191E+00 -0.7168142074761895132795E+00  0.6572151062641362617711E+00 -0.2329070545485949772502E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           758                             0                             0                             0                             0                             0                             0
  0.4186162388803266742876E+00 -0.1252491859380352179354E+00  0.6279917185879517749214E+00 -0.7036424251018875697383E+00  0.6572151062641362617711E+00 -0.2701030205217159196884E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           759                             0                             0                             0                             0                             0                             0
  0.4096325851211477520053E+00 -0.1252491859380352179354E+00  0.6496801773330256324357E+00 -0.6885420077499666557941E+00  0.6572151062641362617711E+00 -0.3065586528902174978661E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           760                             0                             0                             0                             0                             0                             0
  0.3995261569193635509123E+00 -0.1252491859380352179354E+00  0.6708687446891203887134E+00 -0.6715543446147711481586E+00  0.6572151062641362617711E+00 -0.3421740292997777488360E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           761                             0                             0                             0                             0                             0                             0
  0.3883246552921860716978E+00 -0.1252491859380352179354E+00  0.6914993442659121969385E+00 -0.6527259977001567126109E+00  0.6572151062641362617711E+00 -0.3768515304792524056587E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           762                             0                             0                             0                             0                             0                             0
  0.3760587827769686364299E+00 -0.1252491859380352179354E+00  0.7115154290239764645065E+00 -0.6321085741962740867095E+00  0.6572151062641362617711E+00 -0.4104961078083121384097E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           763                             0                             0                             0                             0                             0                             0
  0.3627621592776849035467E+00 -0.1252491859380352179354E+00  0.7308621362662925946552E+00 -0.6097585850278475216868E+00  0.6572151062641362617711E+00 -0.4430155438391041311519E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           764                             0                             0                             0                             0                             0                             0
  0.3484712299151096481786E+00 -0.1252491859380352179354E+00  0.7494864380130820125103E+00 -0.5857372899616594130734E+00  0.6572151062641362617711E+00 -0.4743207050578657213435E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           765                             0                             0                             0                             0                             0                             0
  0.3332251651332752695467E+00 -0.1252491859380352179354E+00  0.7673372863478165051276E+00 -0.5601105296977861858210E+00  0.6572151062641362617711E+00 -0.5043257861936918384771E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           766                             0                             0                             0                             0                             0                             0
  0.3170657533360077273699E+00 -0.1252491859380352179354E+00  0.7843657533360076650197E+00 -0.5329485454048167314411E+00  0.6572151062641362617711E+00 -0.5329485454048166204188E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           767                             0                             0                             0                             0                             0                             0
  0.3000372863478166229889E+00 -0.1252491859380352179354E+00  0.8005251651332752071966E+00 -0.5043257861936920605217E+00  0.6572151062641362617711E+00 -0.5601105296977859637764E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           768                             0                             0                             0                             0                             0                             0
  0.2821864380130820193493E+00 -0.1252491859380352179354E+00  0.8157712299151096413397E+00 -0.4743207050578658323658E+00  0.6572151062641362617711E+00 -0.5857372899616593020511E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           769                             0                             0                             0                             0                             0                             0
  0.2635621362662925459830E+00 -0.1252491859380352179354E+00  0.8300621592776848967077E+00 -0.4430155438391041311519E+00  0.6572151062641362617711E+00 -0.6097585850278475216868E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           770                             0                             0                             0                             0                             0                             0
  0.2442154290239766378789E+00 -0.1252491859380352179354E+00  0.8433587827769685185686E+00 -0.4104961078083124159654E+00  0.6572151062641362617711E+00 -0.6321085741962738646649E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           771                             0                             0                             0                             0                             0                             0
  0.2241993442659122037774E+00 -0.1252491859380352179354E+00  0.8556246552921860093477E+00 -0.3768515304792524056587E+00  0.6572151062641362617711E+00 -0.6527259977001567126109E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           772                             0                             0                             0                             0                             0                             0
  0.2035687446891203955524E+00 -0.1252491859380352179354E+00  0.8668261569193634885622E+00 -0.3421740292997778043471E+00  0.6572151062641362617711E+00 -0.6715543446147710371363E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           773                             0                             0                             0                             0                             0                             0
  0.1823801773330255282524E+00 -0.1252491859380352179354E+00  0.8769325851211478006775E+00 -0.3065586528902173868438E+00  0.6572151062641362617711E+00 -0.6885420077499666557941E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           774                             0                             0                             0                             0                             0                             0
  0.1606917185879516429825E+00 -0.1252491859380352179354E+00  0.8859162388803266674486E+00 -0.2701030205217158086661E+00  0.6572151062641361507488E+00 -0.7036424251018875697383E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           775                             0                             0                             0                             0                             0                             0
  0.1385628150117726442581E+00 -0.1252491859380352179354E+00  0.8937524946263926128864E+00 -0.2329070545485950327613E+00  0.6572151062641362617711E+00 -0.7168142074761895132795E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           776                             0                             0                             0                             0                             0                             0
  0.1160541203910293445167E+00 -0.1252491859380352179354E+00  0.9004198737270372454589E+00 -0.1950727065281270822261E+00  0.6572151062641361507488E+00 -0.7280212519329439802007E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           777                             0                             0                             0                             0                             0                             0
  0.9322732949311741956766E-01 -0.1252491859380352179354E+00  0.9059001013595892048968E+00 -0.1567036777784034384808E+00  0.6572151062641362617711E+00 -0.7372328407422870100163E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           778                             0                             0                             0                             0                             0                             0
  0.7014500896521709549791E-01 -0.1252491859380352179354E+00  0.9101781566010338497819E+00 -0.1179051351402282954428E+00  0.6572151062641363727934E+00 -0.7444237255795818075654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           779                             0                             0                             0                             0                             0                             0
  0.4687042584346270274187E-01 -0.1252491859380352179354E+00  0.9132423135993181784187E+00 -0.7878342272211889818490E-01  0.6572151062641362617711E+00 -0.7495741967293216845292E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           780                             0                             0                             0                             0                             0                             0
  0.2346737414239492836021E-01 -0.1252491859380352179354E+00  0.9150841737130970265923E+00 -0.3944577041849708226584E-01  0.6572151062641361507488E+00 -0.7526701371080900537791E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           781                             0                             0                             0                             0                             0                             0
  0.2265855202205208082040E-15 -0.1252491859380352179354E+00  0.9156986885318245672494E+00 -0.3808623988581558890565E-15  0.6572151062641362617711E+00 -0.7537030609585050333621E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           782                             0                             0                             0                             0                             0                             0
 -0.2346737414239487284906E-01 -0.1252491859380352179354E+00  0.9150841737130970265923E+00  0.3944577041849698512133E-01  0.6572151062641361507488E+00 -0.7526701371080900537791E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           783                             0                             0                             0                             0                             0                             0
 -0.4687042584346264723072E-01 -0.1252491859380352179354E+00  0.9132423135993181784187E+00  0.7878342272211880104038E-01  0.6572151062641362617711E+00 -0.7495741967293216845292E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           784                             0                             0                             0                             0                             0                             0
 -0.7014500896521705386455E-01 -0.1252491859380352179354E+00  0.9101781566010338497819E+00  0.1179051351402282121761E+00  0.6572151062641362617711E+00 -0.7444237255795818075654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           785                             0                             0                             0                             0                             0                             0
 -0.9322732949311737793430E-01 -0.1252491859380352179354E+00  0.9059001013595892048968E+00  0.1567036777784033552141E+00  0.6572151062641362617711E+00 -0.7372328407422870100163E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           786                             0                             0                             0                             0                             0                             0
 -0.1160541203910292890056E+00 -0.1252491859380352179354E+00  0.9004198737270372454589E+00  0.1950727065281269989594E+00  0.6572151062641363727934E+00 -0.7280212519329440912230E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           787                             0                             0                             0                             0                             0                             0
 -0.1385628150117725887469E+00 -0.1252491859380352179354E+00  0.8937524946263926128864E+00  0.2329070545485949494946E+00  0.6572151062641362617711E+00 -0.7168142074761896243018E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           788                             0                             0                             0                             0                             0                             0
 -0.1606917185879515874714E+00 -0.1252491859380352179354E+00  0.8859162388803267784709E+00  0.2701030205217157531550E+00  0.6572151062641362617711E+00 -0.7036424251018876807606E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           789                             0                             0                             0                             0                             0                             0
 -0.1823801773330256392747E+00 -0.1252491859380352179354E+00  0.8769325851211476896552E+00  0.3065586528902176088884E+00  0.6572151062641362617711E+00 -0.6885420077499665447718E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           790                             0                             0                             0                             0                             0                             0
 -0.2035687446891203677968E+00 -0.1252491859380352179354E+00  0.8668261569193635995845E+00  0.3421740292997777488360E+00  0.6572151062641361507488E+00 -0.6715543446147711481586E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           791                             0                             0                             0                             0                             0                             0
 -0.2241993442659121482663E+00 -0.1252491859380352179354E+00  0.8556246552921860093477E+00  0.3768515304792523501476E+00  0.6572151062641361507488E+00 -0.6527259977001567126109E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           792                             0                             0                             0                             0                             0                             0
 -0.2442154290239766101234E+00 -0.1252491859380352179354E+00  0.8433587827769685185686E+00  0.4104961078083123049431E+00  0.6572151062641361507488E+00 -0.6321085741962738646649E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           793                             0                             0                             0                             0                             0                             0
 -0.2635621362662924904718E+00 -0.1252491859380352179354E+00  0.8300621592776848967077E+00  0.4430155438391040756407E+00  0.6572151062641361507488E+00 -0.6097585850278475216868E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           794                             0                             0                             0                             0                             0                             0
 -0.2821864380130820193493E+00 -0.1252491859380352179354E+00  0.8157712299151096413397E+00  0.4743207050578657213435E+00  0.6572151062641362617711E+00 -0.5857372899616594130734E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           795                             0                             0                             0                             0                             0                             0
 -0.3000372863478165674778E+00 -0.1252491859380352179354E+00  0.8005251651332752071966E+00  0.5043257861936919494994E+00  0.6572151062641362617711E+00 -0.5601105296977860747987E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           796                             0                             0                             0                             0                             0                             0
 -0.3170657533360076718587E+00 -0.1252491859380352179354E+00  0.7843657533360077760420E+00  0.5329485454048166204188E+00  0.6572151062641362617711E+00 -0.5329485454048167314411E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           797                             0                             0                             0                             0                             0                             0
 -0.3332251651332751030132E+00 -0.1252491859380352179354E+00  0.7673372863478166161499E+00  0.5601105296977858527541E+00  0.6572151062641362617711E+00 -0.5043257861936920605217E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           798                             0                             0                             0                             0                             0                             0
 -0.3484712299151094816452E+00 -0.1252491859380352179354E+00  0.7494864380130821235326E+00  0.5857372899616591910288E+00  0.6572151062641362617711E+00 -0.4743207050578660544105E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           799                             0                             0                             0                             0                             0                             0
 -0.3627621592776848480355E+00 -0.1252491859380352179354E+00  0.7308621362662925946552E+00  0.6097585850278474106645E+00  0.6572151062641362617711E+00 -0.4430155438391042421742E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           800                             0                             0                             0                             0                             0                             0
 -0.3760587827769686364299E+00 -0.1252491859380352179354E+00  0.7115154290239765755288E+00  0.6321085741962740867095E+00  0.6572151062641363727934E+00 -0.4104961078083122494320E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           801                             0                             0                             0                             0                             0                             0
 -0.3883246552921860161867E+00 -0.1252491859380352179354E+00  0.6914993442659124189831E+00  0.6527259977001566015886E+00  0.6572151062641362617711E+00 -0.3768515304792527942368E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           802                             0                             0                             0                             0                             0                             0
 -0.3995261569193634954011E+00 -0.1252491859380352179354E+00  0.6708687446891203887134E+00  0.6715543446147710371363E+00  0.6572151062641362617711E+00 -0.3421740292997778598583E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           803                             0                             0                             0                             0                             0                             0
 -0.4096325851211475854718E+00 -0.1252491859380352179354E+00  0.6496801773330258544803E+00  0.6885420077499664337495E+00  0.6572151062641362617711E+00 -0.3065586528902179974665E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           804                             0                             0                             0                             0                             0                             0
 -0.4186162388803267853099E+00 -0.1252491859380352179354E+00  0.6279917185879515528768E+00  0.7036424251018877917829E+00  0.6572151062641362617711E+00 -0.2701030205217155866215E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           805                             0                             0                             0                             0                             0                             0
 -0.4264524946263926197254E+00 -0.1252491859380352179354E+00  0.6058628150117726374191E+00  0.7168142074761895132795E+00  0.6572151062641362617711E+00 -0.2329070545485950605169E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           806                             0                             0                             0                             0                             0                             0
 -0.4331198737270371967867E+00 -0.1252491859380352179354E+00  0.5833541203910292960444E+00  0.7280212519329439802007E+00  0.6572151062641361507488E+00 -0.1950727065281271377373E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           807                             0                             0                             0                             0                             0                             0
 -0.4386001013595891562247E+00 -0.1252491859380352179354E+00  0.5605273294931176764067E+00  0.7372328407422868989940E+00  0.6572151062641362617711E+00 -0.1567036777784038270589E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           808                             0                             0                             0                             0                             0                             0
 -0.4428781566010337455985E+00 -0.1252491859380352179354E+00  0.5374450089652170747812E+00  0.7444237255795816965431E+00  0.6572151062641362617711E+00 -0.1179051351402283370762E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           809                             0                             0                             0                             0                             0                             0
 -0.4459423135993181297465E+00 -0.1252491859380352179354E+00  0.5141704258434631746866E+00  0.7495741967293216845292E+00  0.6572151062641363727934E+00 -0.7878342272211960595207E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           810                             0                             0                             0                             0                             0                             0
 -0.4477841737130970334313E+00 -0.1252491859380352179354E+00  0.4907673741423947411100E+00  0.7526701371080901648014E+00  0.6572151062641362617711E+00 -0.3944577041849679083230E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           811                             0                             0                             0                             0                             0                             0
 -0.4483986885318245185772E+00 -0.1252491859380352179354E+00  0.4673000000000000486722E+00  0.7537030609585050333621E+00  0.6572151062641362617711E+00 -0.9230200411103956068004E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           812                             0                             0                             0                             0                             0                             0
 -0.4477841737130969779201E+00 -0.1252491859380352179354E+00  0.4438326258576049676563E+00  0.7526701371080900537791E+00  0.6572151062641362617711E+00  0.3944577041849727655487E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           813                             0                             0                             0                             0                             0                             0
 -0.4459423135993181852577E+00 -0.1252491859380352179354E+00  0.4204295741565373667470E+00  0.7495741967293216845292E+00  0.6572151062641362617711E+00  0.7878342272211875940702E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           814                             0                             0                             0                             0                             0                             0
 -0.4428781566010338011097E+00 -0.1252491859380352179354E+00  0.3971549910347829670521E+00  0.7444237255795818075654E+00  0.6572151062641362617711E+00  0.1179051351402281427871E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           815                             0                             0                             0                             0                             0                             0
 -0.4386001013595891562247E+00 -0.1252491859380352179354E+00  0.3740726705068824209377E+00  0.7372328407422868989940E+00  0.6572151062641361507488E+00  0.1567036777784036327699E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           816                             0                             0                             0                             0                             0                             0
 -0.4331198737270371412755E+00 -0.1252491859380352179354E+00  0.3512458796089703572108E+00  0.7280212519329438691784E+00  0.6572151062641362617711E+00  0.1950727065281275818265E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           817                             0                             0                             0                             0                             0                             0
 -0.4264524946263926752366E+00 -0.1252491859380352179354E+00  0.3287371849882274599253E+00  0.7168142074761896243018E+00  0.6572151062641361507488E+00  0.2329070545485948939834E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           818                             0                             0                             0                             0                             0                             0
 -0.4186162388803267853099E+00 -0.1252491859380352179354E+00  0.3066082814120485999787E+00  0.7036424251018877917829E+00  0.6572151062641361507488E+00  0.2701030205217154200881E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           819                             0                             0                             0                             0                             0                             0
 -0.4096325851211477520053E+00 -0.1252491859380352179354E+00  0.2849198226669745759310E+00  0.6885420077499667668164E+00  0.6572151062641363727934E+00  0.3065586528902172758215E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           820                             0                             0                             0                             0                             0                             0
 -0.3995261569193635509123E+00 -0.1252491859380352179354E+00  0.2637312553108795976087E+00  0.6715543446147711481586E+00  0.6572151062641361507488E+00  0.3421740292997777488360E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           821                             0                             0                             0                             0                             0                             0
 -0.3883246552921860716978E+00 -0.1252491859380352179354E+00  0.2431006557340876783613E+00  0.6527259977001567126109E+00  0.6572151062641362617711E+00  0.3768515304792526277033E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           822                             0                             0                             0                             0                             0                             0
 -0.3760587827769686919410E+00 -0.1252491859380352179354E+00  0.2230845709760235495711E+00  0.6321085741962741977318E+00  0.6572151062641362617711E+00  0.4104961078083120828985E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           823                             0                             0                             0                             0                             0                             0
 -0.3627621592776849590578E+00 -0.1252491859380352179354E+00  0.2037378637337075026892E+00  0.6097585850278476327091E+00  0.6572151062641363727934E+00  0.4430155438391040756407E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           824                             0                             0                             0                             0                             0                             0
 -0.3484712299151098147121E+00 -0.1252491859380352179354E+00  0.1851135619869181958563E+00  0.5857372899616596351180E+00  0.6572151062641362617711E+00  0.4743207050578653882766E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           825                             0                             0                             0                             0                             0                             0
 -0.3332251651332750475021E+00 -0.1252491859380352179354E+00  0.1672627136521833146610E+00  0.5601105296977858527541E+00  0.6572151062641362617711E+00  0.5043257861936921715440E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           826                             0                             0                             0                             0                             0                             0
 -0.3170657533360077828810E+00 -0.1252491859380352179354E+00  0.1502342466639923213023E+00  0.5329485454048168424634E+00  0.6572151062641363727934E+00  0.5329485454048166204188E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           827                             0                             0                             0                             0                             0                             0
 -0.3000372863478165119666E+00 -0.1252491859380352179354E+00  0.1340748348667247791255E+00  0.5043257861936918384771E+00  0.6572151062641362617711E+00  0.5601105296977861858210E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           828                             0                             0                             0                             0                             0                             0
 -0.2821864380130822413939E+00 -0.1252491859380352179354E+00  0.1188287700848905670270E+00  0.4743207050578661654328E+00  0.6572151062641362617711E+00  0.5857372899616590800065E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           829                             0                             0                             0                             0                             0                             0
 -0.2635621362662926014941E+00 -0.1252491859380352179354E+00  0.1045378407223151451255E+00  0.4430155438391042421742E+00  0.6572151062641362617711E+00  0.6097585850278474106645E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           830                             0                             0                             0                             0                             0                             0
 -0.2442154290239768876791E+00 -0.1252491859380352179354E+00  0.9124121722303163428691E-01  0.4104961078083128045435E+00  0.6572151062641363727934E+00  0.6321085741962736426203E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           831                             0                             0                             0                             0                             0                             0
 -0.2241993442659120927551E+00 -0.1252491859380352179354E+00  0.7897534470781386595206E-01  0.3768515304792522391253E+00  0.6572151062641361507488E+00  0.6527259977001568236332E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           832                             0                             0                             0                             0                             0                             0
 -0.2035687446891204510635E+00 -0.1252491859380352179354E+00  0.6777384308063649775988E-01  0.3421740292997779153694E+00  0.6572151062641362617711E+00  0.6715543446147710371363E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           833                             0                             0                             0                             0                             0                             0
 -0.1823801773330255560079E+00 -0.1252491859380352179354E+00  0.5766741487885224115573E-01  0.3065586528902174423550E+00  0.6572151062641362617711E+00  0.6885420077499666557941E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           834                             0                             0                             0                             0                             0                             0
 -0.1606917185879518927827E+00 -0.1252491859380352179354E+00  0.4868376111967337438458E-01  0.2701030205217162527553E+00  0.6572151062641362617711E+00  0.7036424251018874587160E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           835                             0                             0                             0                             0                             0                             0
 -0.1385628150117726720136E+00 -0.1252491859380352179354E+00  0.4084750537360737343562E-01  0.2329070545485951160281E+00  0.6572151062641362617711E+00  0.7168142074761895132795E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           836                             0                             0                             0                             0                             0                             0
 -0.1160541203910293861501E+00 -0.1252491859380352179354E+00  0.3418012627296279637434E-01  0.1950727065281271654928E+00  0.6572151062641362617711E+00  0.7280212519329439802007E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           837                             0                             0                             0                             0                             0                             0
 -0.9322732949311728078978E-01 -0.1252491859380352179354E+00  0.2869989864041078142520E-01  0.1567036777784032164362E+00  0.6572151062641362617711E+00  0.7372328407422870100163E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           838                             0                             0                             0                             0                             0                             0
 -0.7014500896521715100906E-01 -0.1252491859380352179354E+00  0.2442184339896624756250E-01  0.1179051351402283787095E+00  0.6572151062641362617711E+00  0.7444237255795816965431E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           839                             0                             0                             0                             0                             0                             0
 -0.4687042584346275825302E-01 -0.1252491859380352179354E+00  0.2135768640068180790337E-01  0.7878342272211899532941E-01  0.6572151062641362617711E+00  0.7495741967293216845292E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           840                             0                             0                             0                             0                             0                             0
 -0.2346737414239518162984E-01 -0.1252491859380352179354E+00  0.1951582628690301524088E-01  0.3944577041849750553837E-01  0.6572151062641362617711E+00  0.7526701371080900537791E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           841                             0                             0                             0                             0                             0                             0
  0.2829753959675105425265E-16 -0.1043862266863211651913E+00  0.5166107738934999638047E-02 -0.5673639514979832001175E-16  0.3761084501259887025171E+00  0.9265756492288292900383E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           842                             0                             0                             0                             0                             0                             0
  0.2418621916375647898367E-01 -0.1043862266863211651913E+00  0.5799446177012335112977E-02 -0.4849322263381740383270E-01  0.3761084501259887025171E+00  0.9253058095043029673832E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           843                             0                             0                             0                             0                             0                             0
  0.4830614558194844948558E-01 -0.1043862266863211651913E+00  0.7697725554608236819831E-02 -0.9685352871511783423575E-01  0.3761084501259886470059E+00  0.9214997708731436087959E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           844                             0                             0                             0                             0                             0                             0
  0.7229366821281942023791E-01 -0.1043862266863211651913E+00  0.1085574281989654110703E-01 -0.1449483660064165568837E+00  0.3761084501259887580282E+00  0.9151679654226848592558E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           845                             0                             0                             0                             0                             0                             0
  0.9608303892419030323158E-01 -0.1043862266863211651913E+00  0.1526484206706424373579E-01 -0.1926459099017290843570E+00  0.3761084501259886470059E+00  0.9063277481915475997098E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           846                             0                             0                             0                             0                             0                             0
  0.1196090527045200468947E+00 -0.1043862266863211651913E+00  0.2091293826154749790902E-01 -0.2398154247486538048761E+00  0.3761084501259887580282E+00  0.8950033496006868372064E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           847                             0                             0                             0                             0                             0                             0
  0.1428072263853100987152E+00 -0.1043862266863211651913E+00  0.2778455036427168733937E-01 -0.2863276221857083969624E+00  0.3761084501259887025171E+00  0.8812258090394905485354E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           848                             0                             0                             0                             0                             0                             0
  0.1656139753849866225188E+00 -0.1043862266863211651913E+00  0.3586084376410303420357E-01 -0.3320550155127410252298E+00  0.3761084501259887025171E+00  0.8650328897889720813907E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           849                             0                             0                             0                             0                             0                             0
  0.1879667879898191118482E+00 -0.1043862266863211651913E+00  0.4511968190220899677101E-01 -0.3768722691231141674884E+00  0.3761084501259886470059E+00  0.8464689755152409178507E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           850                             0                             0                             0                             0                             0                             0
  0.2098043966941827709327E+00 -0.1043862266863211651913E+00  0.5553568694682681217145E-01 -0.4206565420398912236166E+00  0.3761084501259886470059E+00  0.8255849486169595241591E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           851                             0                             0                             0                             0                             0                             0
  0.2310669461305324412503E+00 -0.1043862266863211651913E+00  0.6708030935213687984131E-01 -0.4632878246144145339969E+00  0.3761084501259887025171E+00  0.8024380507602253409516E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           852                             0                             0                             0                             0                             0                             0
  0.2516961571288049426265E+00 -0.1043862266863211651913E+00  0.7972190611058321829674E-01 -0.5046492674644118547889E+00  0.3761084501259887580282E+00  0.7770917259831422452265E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           853                             0                             0                             0                             0                             0                             0
  0.2716354864555726722486E+00 -0.1043862266863211651913E+00  0.9342582748415739768433E-01 -0.5446275017500294968187E+00  0.3761084501259887025171E+00  0.7496154468001230419816E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           854                             0                             0                             0                             0                             0                             0
  0.2908302817951168850463E+00 -0.1043862266863211651913E+00  0.1081545119769224960748E+00 -0.5831129499099438895371E+00  0.3761084501259887025171E+00  0.7200845237825554967515E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           855                             0                             0                             0                             0                             0                             0
  0.3092279315476256784656E+00 -0.1043862266863211651913E+00  0.1238675892884619766932E+00 -0.6200001260058393137697E+00  0.3761084501259886470059E+00  0.6885798991377615196896E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           856                             0                             0                             0                             0                             0                             0
  0.3267780090339323928461E+00 -0.1043862266863211651913E+00  0.1405219909660675448038E+00 -0.6551879248520329213079E+00  0.3761084501259887025171E+00  0.6551879248520330323302E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           857                             0                             0                             0                             0                             0                             0
  0.3434324107115380719790E+00 -0.1043862266863211651913E+00  0.1580720684523743146954E+00 -0.6885798991377616307119E+00  0.3761084501259887025171E+00  0.6200001260058393137697E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           858                             0                             0                             0                             0                             0                             0
  0.3591454880230775525973E+00 -0.1043862266863211651913E+00  0.1764697182048831636259E+00 -0.7200845237825556077738E+00  0.3761084501259887025171E+00  0.5831129499099437785148E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           859                             0                             0                             0                             0                             0                             0
  0.3738741725158425954767E+00 -0.1043862266863211651913E+00  0.1956645135444273209124E+00 -0.7496154468001230419816E+00  0.3761084501259887025171E+00  0.5446275017500294968187E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           860                             0                             0                             0                             0                             0                             0
  0.3875780938894167748643E+00 -0.1043862266863211651913E+00  0.2156038428711950505345E+00 -0.7770917259831422452265E+00  0.3761084501259887580282E+00  0.5046492674644118547889E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           861                             0                             0                             0                             0                             0                             0
  0.4002196906478630578086E+00 -0.1043862266863211651913E+00  0.2362330538694674963995E+00 -0.8024380507602252299293E+00  0.3761084501259887025171E+00  0.4632878246144146450192E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           862                             0                             0                             0                             0                             0                             0
  0.4117643130531732365007E+00 -0.1043862266863211651913E+00  0.2574956033058172222283E+00 -0.8255849486169595241591E+00  0.3761084501259887025171E+00  0.4206565420398911681055E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           863                             0                             0                             0                             0                             0                             0
  0.4221803180977909963900E+00 -0.1043862266863211651913E+00  0.2793332120101808535573E+00 -0.8464689755152409178507E+00  0.3761084501259887025171E+00  0.3768722691231142785107E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           864                             0                             0                             0                             0                             0                             0
  0.4314391562358969589575E+00 -0.1043862266863211651913E+00  0.3016860246150133706422E+00 -0.8650328897889720813907E+00  0.3761084501259887025171E+00  0.3320550155127409697187E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           865                             0                             0                             0                             0                             0                             0
  0.4395154496357283058217E+00 -0.1043862266863211651913E+00  0.3244927736146899222014E+00 -0.8812258090394905485354E+00  0.3761084501259886470059E+00  0.2863276221857083969624E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           866                             0                             0                             0                             0                             0                             0
  0.4463870617384524952520E+00 -0.1043862266863211651913E+00  0.3476909472954800017774E+00 -0.8950033496006868372064E+00  0.3761084501259887580282E+00  0.2398154247486537493650E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           867                             0                             0                             0                             0                             0                             0
  0.4520351579329357494252E+00 -0.1043862266863211651913E+00  0.3712169610758098148295E+00 -0.9063277481915477107322E+00  0.3761084501259887025171E+00  0.1926459099017288345568E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           868                             0                             0                             0                             0                             0                             0
  0.4564442571801034520540E+00 -0.1043862266863211651913E+00  0.3950063317871805868009E+00 -0.9151679654226848592558E+00  0.3761084501259887025171E+00  0.1449483660064165291281E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           869                             0                             0                             0                             0                             0                             0
  0.4596022744453917563412E+00 -0.1043862266863211651913E+00  0.4189938544180515922477E+00 -0.9214997708731436087959E+00  0.3761084501259886470059E+00  0.9685352871511777872460E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           870                             0                             0                             0                             0                             0                             0
  0.4615005538229876580480E+00 -0.1043862266863211651913E+00  0.4431137808362436425469E+00 -0.9253058095043029673832E+00  0.3761084501259887025171E+00  0.4849322263381714015473E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           871                             0                             0                             0                             0                             0                             0
  0.4621338922610649935230E+00 -0.1043862266863211651913E+00  0.4672999999999998821387E+00 -0.9265756492288292900383E+00  0.3761084501259887025171E+00  0.2057411239661697899358E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           872                             0                             0                             0                             0                             0                             0
  0.4615005538229876580480E+00 -0.1043862266863211651913E+00  0.4914862191637563437752E+00 -0.9253058095043029673832E+00  0.3761084501259887025171E+00 -0.4849322263381714015473E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           873                             0                             0                             0                             0                             0                             0
  0.4596022744453917563412E+00 -0.1043862266863211651913E+00  0.5156061455819483940743E+00 -0.9214997708731436087959E+00  0.3761084501259886470059E+00 -0.9685352871511777872460E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           874                             0                             0                             0                             0                             0                             0
  0.4564442571801034520540E+00 -0.1043862266863211651913E+00  0.5395936682128193995212E+00 -0.9151679654226848592558E+00  0.3761084501259887025171E+00 -0.1449483660064165291281E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           875                             0                             0                             0                             0                             0                             0
  0.4520351579329357494252E+00 -0.1043862266863211651913E+00  0.5633830389241902825148E+00 -0.9063277481915475997098E+00  0.3761084501259886470059E+00 -0.1926459099017290288458E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           876                             0                             0                             0                             0                             0                             0
  0.4463870617384524952520E+00 -0.1043862266863211651913E+00  0.5869090527045199845446E+00 -0.8950033496006868372064E+00  0.3761084501259887580282E+00 -0.2398154247486537493650E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           877                             0                             0                             0                             0                             0                             0
  0.4395154496357283058217E+00 -0.1043862266863211651913E+00  0.6101072263853100086095E+00 -0.8812258090394905485354E+00  0.3761084501259886470059E+00 -0.2863276221857083969624E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           878                             0                             0                             0                             0                             0                             0
  0.4314391562358969589575E+00 -0.1043862266863211651913E+00  0.6329139753849866156798E+00 -0.8650328897889720813907E+00  0.3761084501259887025171E+00 -0.3320550155127409697187E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           879                             0                             0                             0                             0                             0                             0
  0.4221803180977910519012E+00 -0.1043862266863211651913E+00  0.6552667879898190772536E+00 -0.8464689755152409178507E+00  0.3761084501259887580282E+00 -0.3768722691231141674884E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           880                             0                             0                             0                             0                             0                             0
  0.4117643130531732365007E+00 -0.1043862266863211651913E+00  0.6771043966941827640937E+00 -0.8255849486169595241591E+00  0.3761084501259887025171E+00 -0.4206565420398911681055E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           881                             0                             0                             0                             0                             0                             0
  0.4002196906478631133197E+00 -0.1043862266863211651913E+00  0.6983669461305324066558E+00 -0.8024380507602253409516E+00  0.3761084501259887025171E+00 -0.4632878246144144784857E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           882                             0                             0                             0                             0                             0                             0
  0.3875780938894168303754E+00 -0.1043862266863211651913E+00  0.7189961571288048247652E+00 -0.7770917259831423562488E+00  0.3761084501259886470059E+00 -0.5046492674644116327443E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           883                             0                             0                             0                             0                             0                             0
  0.3738741725158425954767E+00 -0.1043862266863211651913E+00  0.7389354864555726098985E+00 -0.7496154468001230419816E+00  0.3761084501259887025171E+00 -0.5446275017500294968187E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           884                             0                             0                             0                             0                             0                             0
  0.3591454880230776081085E+00 -0.1043862266863211651913E+00  0.7581302817951167671850E+00 -0.7200845237825556077738E+00  0.3761084501259887025171E+00 -0.5831129499099436674925E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           885                             0                             0                             0                             0                             0                             0
  0.3434324107115381830013E+00 -0.1043862266863211651913E+00  0.7765279315476255606043E+00 -0.6885798991377618527565E+00  0.3761084501259887025171E+00 -0.6200001260058390917251E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           886                             0                             0                             0                             0                             0                             0
  0.3267780090339324483573E+00 -0.1043862266863211651913E+00  0.7940780090339323304960E+00 -0.6551879248520330323302E+00  0.3761084501259887025171E+00 -0.6551879248520329213079E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           887                             0                             0                             0                             0                             0                             0
  0.3092279315476257339768E+00 -0.1043862266863211651913E+00  0.8107324107115380096289E+00 -0.6200001260058394247920E+00  0.3761084501259887025171E+00 -0.6885798991377615196896E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           888                             0                             0                             0                             0                             0                             0
  0.2908302817951168295352E+00 -0.1043862266863211651913E+00  0.8264454880230776012695E+00 -0.5831129499099437785148E+00  0.3761084501259887025171E+00 -0.7200845237825556077738E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           889                             0                             0                             0                             0                             0                             0
  0.2716354864555726722486E+00 -0.1043862266863211651913E+00  0.8411741725158425886377E+00 -0.5446275017500294968187E+00  0.3761084501259887025171E+00 -0.7496154468001230419816E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           890                             0                             0                             0                             0                             0                             0
  0.2516961571288049981376E+00 -0.1043862266863211651913E+00  0.8548780938894167125142E+00 -0.5046492674644119658112E+00  0.3761084501259887025171E+00 -0.7770917259831421342042E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           891                             0                             0                             0                             0                             0                             0
  0.2310669461305324412503E+00 -0.1043862266863211651913E+00  0.8675196906478630509696E+00 -0.4632878246144145339969E+00  0.3761084501259887025171E+00 -0.8024380507602253409516E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           892                             0                             0                             0                             0                             0                             0
  0.2098043966941827709327E+00 -0.1043862266863211651913E+00  0.8790643130531732296618E+00 -0.4206565420398912236166E+00  0.3761084501259886470059E+00 -0.8255849486169595241591E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           893                             0                             0                             0                             0                             0                             0
  0.1879667879898190008259E+00 -0.1043862266863211651913E+00  0.8894803180977910450622E+00 -0.3768722691231140009549E+00  0.3761084501259887025171E+00 -0.8464689755152409178507E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           894                             0                             0                             0                             0                             0                             0
  0.1656139753849865114965E+00 -0.1043862266863211651913E+00  0.8987391562358969521185E+00 -0.3320550155127408586964E+00  0.3761084501259886470059E+00 -0.8650328897889720813907E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           895                             0                             0                             0                             0                             0                             0
  0.1428072263853100987152E+00 -0.1043862266863211651913E+00  0.9068154496357283544938E+00 -0.2863276221857083969624E+00  0.3761084501259887025171E+00 -0.8812258090394905485354E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           896                             0                             0                             0                             0                             0                             0
  0.1196090527045199358724E+00 -0.1043862266863211651913E+00  0.9136870617384524884130E+00 -0.2398154247486536105871E+00  0.3761084501259887025171E+00 -0.8950033496006868372064E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           897                             0                             0                             0                             0                             0                             0
  0.9608303892419020608706E-01 -0.1043862266863211651913E+00  0.9193351579329357425863E+00 -0.1926459099017288900679E+00  0.3761084501259887580282E+00 -0.9063277481915477107322E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           898                             0                             0                             0                             0                             0                             0
  0.7229366821281942023791E-01 -0.1043862266863211651913E+00  0.9237442571801034452150E+00 -0.1449483660064165568837E+00  0.3761084501259887580282E+00 -0.9151679654226848592558E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           899                             0                             0                             0                             0                             0                             0
