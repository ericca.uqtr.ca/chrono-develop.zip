  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           368                             1                             2                           368                           369                           488                           489
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           369                             1                             2                           369                           370                           489                           490
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           370                             1                             2                           370                           371                           490                           491
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           371                             1                             2                           371                           372                           491                           492
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           372                             1                             2                           372                           373                           492                           493
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           373                             1                             2                           373                           374                           493                           494
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           374                             1                             2                           374                           375                           494                           495
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           375                             1                             2                           375                           376                           495                           496
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           376                             1                             2                           376                           377                           496                           497
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           377                             1                             2                           377                           378                           497                           498
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           378                             1                             2                           378                           379                           498                           499
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           379                             1                             2                           379                           380                           499                           500
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           380                             1                             2                           380                           381                           500                           501
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           381                             1                             2                           381                           382                           501                           502
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           382                             1                             2                           382                           383                           502                           503
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           383                             1                             2                           383                           384                           503                           504
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           384                             1                             2                           384                           385                           504                           505
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           385                             1                             2                           385                           386                           505                           506
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           386                             1                             2                           386                           387                           506                           507
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           387                             1                             2                           387                           388                           507                           508
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           388                             1                             2                           388                           389                           508                           509
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           389                             1                             2                           389                           390                           509                           510
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           390                             1                             2                           390                           391                           510                           511
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           391                             1                             2                           391                           392                           511                           512
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           392                             1                             2                           392                           393                           512                           513
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           393                             1                             2                           393                           394                           513                           514
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           394                             1                             2                           394                           395                           514                           515
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           395                             1                             2                           395                           396                           515                           516
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           396                             1                             2                           396                           397                           516                           517
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           397                             1                             2                           397                           398                           517                           518
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           398                             1                             2                           398                           399                           518                           519
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           399                             1                             2                           399                           400                           519                           520
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           400                             1                             2                           400                           401                           520                           521
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           401                             1                             2                           401                           402                           521                           522
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           402                             1                             2                           402                           403                           522                           523
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           403                             1                             2                           403                           404                           523                           524
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           404                             1                             2                           404                           405                           524                           525
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           405                             1                             2                           405                           406                           525                           526
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           406                             1                             2                           406                           407                           526                           527
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           407                             1                             2                           407                           408                           527                           528
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           408                             1                             2                           408                           409                           528                           529
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           409                             1                             2                           409                           410                           529                           530
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           410                             1                             2                           410                           411                           530                           531
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           411                             1                             2                           411                           412                           531                           532
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           412                             1                             2                           412                           413                           532                           533
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           413                             1                             2                           413                           414                           533                           534
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           414                             1                             2                           414                           415                           534                           535
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           415                             1                             2                           415                           416                           535                           536
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           416                             1                             2                           416                           417                           536                           537
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           417                             1                             2                           417                           418                           537                           538
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           418                             1                             2                           418                           419                           538                           539
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           419                             1                             2                           419                           420                           539                           540
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           420                             1                             2                           420                           421                           540                           541
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           421                             1                             2                           421                           422                           541                           542
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           422                             1                             2                           422                           423                           542                           543
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           423                             1                             2                           423                           424                           543                           544
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           424                             1                             2                           424                           425                           544                           545
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           425                             1                             2                           425                           426                           545                           546
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           426                             1                             2                           426                           427                           546                           547
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           427                             1                             2                           427                           428                           547                           548
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           428                             1                             2                           428                           429                           548                           549
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           429                             1                             2                           429                           430                           549                           550
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           430                             1                             2                           430                           431                           550                           551
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           431                             1                             2                           431                           432                           551                           552
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           432                             1                             2                           432                           433                           552                           553
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           433                             1                             2                           433                           434                           553                           554
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           434                             1                             2                           434                           435                           554                           555
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           435                             1                             2                           435                           436                           555                           556
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           436                             1                             2                           436                           437                           556                           557
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           437                             1                             2                           437                           438                           557                           558
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           438                             1                             2                           438                           439                           558                           559
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           439                             1                             2                           439                           440                           559                           560
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           440                             1                             2                           440                           441                           560                           561
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           441                             1                             2                           441                           442                           561                           562
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           442                             1                             2                           442                           443                           562                           563
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           443                             1                             2                           443                           444                           563                           564
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           444                             1                             2                           444                           445                           564                           565
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           445                             1                             2                           445                           446                           565                           566
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           446                             1                             2                           446                           447                           566                           567
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           447                             1                             2                           447                           448                           567                           568
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           448                             1                             2                           448                           449                           568                           569
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           449                             1                             2                           449                           450                           569                           570
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           450                             1                             2                           450                           451                           570                           571
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           451                             1                             2                           451                           452                           571                           572
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           452                             1                             2                           452                           453                           572                           573
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           453                             1                             2                           453                           454                           573                           574
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           454                             1                             2                           454                           455                           574                           575
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           455                             1                             2                           455                           456                           575                           576
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           456                             1                             2                           456                           457                           576                           577
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           457                             1                             2                           457                           458                           577                           578
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           458                             1                             2                           458                           459                           578                           579
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           459                             1                             2                           459                           460                           579                           580
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           460                             1                             2                           460                           461                           580                           581
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           461                             1                             2                           461                           462                           581                           582
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           462                             1                             2                           462                           463                           582                           583
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           463                             1                             2                           463                           464                           583                           584
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           464                             1                             2                           464                           465                           584                           585
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           465                             1                             2                           465                           466                           585                           586
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           466                             1                             2                           466                           467                           586                           587
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           467                             1                             2                           467                           468                           587                           588
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           468                             1                             2                           468                           469                           588                           589
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           469                             1                             2                           469                           470                           589                           590
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           470                             1                             2                           470                           471                           590                           591
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           471                             1                             2                           471                           472                           591                           592
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           472                             1                             2                           472                           473                           592                           593
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           473                             1                             2                           473                           474                           593                           594
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           474                             1                             2                           474                           475                           594                           595
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           475                             1                             2                           475                           476                           595                           596
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           476                             1                             2                           476                           477                           596                           597
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           477                             1                             2                           477                           478                           597                           598
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           478                             1                             2                           478                           479                           598                           599
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           479                             1                             2                           479                           480                           599                           600
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           480                             1                             2                           480                           361                           600                           481
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           481                             1                             2                           481                           482                           601                           602
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           482                             1                             2                           482                           483                           602                           603
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           483                             1                             2                           483                           484                           603                           604
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           484                             1                             2                           484                           485                           604                           605
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           485                             1                             2                           485                           486                           605                           606
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           486                             1                             2                           486                           487                           606                           607
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           487                             1                             2                           487                           488                           607                           608
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           488                             1                             2                           488                           489                           608                           609
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           489                             1                             2                           489                           490                           609                           610
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           490                             1                             2                           490                           491                           610                           611
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           491                             1                             2                           491                           492                           611                           612
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           492                             1                             2                           492                           493                           612                           613
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           493                             1                             2                           493                           494                           613                           614
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           494                             1                             2                           494                           495                           614                           615
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           495                             1                             2                           495                           496                           615                           616
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           496                             1                             2                           496                           497                           616                           617
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           497                             1                             2                           497                           498                           617                           618
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           498                             1                             2                           498                           499                           618                           619
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           499                             1                             2                           499                           500                           619                           620
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           500                             1                             2                           500                           501                           620                           621
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           501                             1                             2                           501                           502                           621                           622
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           502                             1                             2                           502                           503                           622                           623
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           503                             1                             2                           503                           504                           623                           624
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           504                             1                             2                           504                           505                           624                           625
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           505                             1                             2                           505                           506                           625                           626
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           506                             1                             2                           506                           507                           626                           627
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           507                             1                             2                           507                           508                           627                           628
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           508                             1                             2                           508                           509                           628                           629
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           509                             1                             2                           509                           510                           629                           630
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           510                             1                             2                           510                           511                           630                           631
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           511                             1                             2                           511                           512                           631                           632
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           512                             1                             2                           512                           513                           632                           633
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           513                             1                             2                           513                           514                           633                           634
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           514                             1                             2                           514                           515                           634                           635
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           515                             1                             2                           515                           516                           635                           636
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           516                             1                             2                           516                           517                           636                           637
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           517                             1                             2                           517                           518                           637                           638
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           518                             1                             2                           518                           519                           638                           639
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           519                             1                             2                           519                           520                           639                           640
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           520                             1                             2                           520                           521                           640                           641
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           521                             1                             2                           521                           522                           641                           642
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           522                             1                             2                           522                           523                           642                           643
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           523                             1                             2                           523                           524                           643                           644
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           524                             1                             2                           524                           525                           644                           645
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           525                             1                             2                           525                           526                           645                           646
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           526                             1                             2                           526                           527                           646                           647
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           527                             1                             2                           527                           528                           647                           648
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           528                             1                             2                           528                           529                           648                           649
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           529                             1                             2                           529                           530                           649                           650
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           530                             1                             2                           530                           531                           650                           651
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           531                             1                             2                           531                           532                           651                           652
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           532                             1                             2                           532                           533                           652                           653
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           533                             1                             2                           533                           534                           653                           654
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           534                             1                             2                           534                           535                           654                           655
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           535                             1                             2                           535                           536                           655                           656
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           536                             1                             2                           536                           537                           656                           657
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           537                             1                             2                           537                           538                           657                           658
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           538                             1                             2                           538                           539                           658                           659
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           539                             1                             2                           539                           540                           659                           660
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           540                             1                             2                           540                           541                           660                           661
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           541                             1                             2                           541                           542                           661                           662
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           542                             1                             2                           542                           543                           662                           663
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           543                             1                             2                           543                           544                           663                           664
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           544                             1                             2                           544                           545                           664                           665
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           545                             1                             2                           545                           546                           665                           666
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           546                             1                             2                           546                           547                           666                           667
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           547                             1                             2                           547                           548                           667                           668
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           548                             1                             2                           548                           549                           668                           669
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           549                             1                             2                           549                           550                           669                           670
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           550                             1                             2                           550                           551                           670                           671
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           551                             1                             2                           551                           552                           671                           672
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           552                             1                             2                           552                           553                           672                           673
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           553                             1                             2                           553                           554                           673                           674
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           554                             1                             2                           554                           555                           674                           675
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           555                             1                             2                           555                           556                           675                           676
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           556                             1                             2                           556                           557                           676                           677
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           557                             1                             2                           557                           558                           677                           678
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           558                             1                             2                           558                           559                           678                           679
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           559                             1                             2                           559                           560                           679                           680
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           560                             1                             2                           560                           561                           680                           681
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           561                             1                             2                           561                           562                           681                           682
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           562                             1                             2                           562                           563                           682                           683
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           563                             1                             2                           563                           564                           683                           684
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           564                             1                             2                           564                           565                           684                           685
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           565                             1                             2                           565                           566                           685                           686
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           566                             1                             2                           566                           567                           686                           687
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           567                             1                             2                           567                           568                           687                           688
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           568                             1                             2                           568                           569                           688                           689
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           569                             1                             2                           569                           570                           689                           690
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           570                             1                             2                           570                           571                           690                           691
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           571                             1                             2                           571                           572                           691                           692
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           572                             1                             2                           572                           573                           692                           693
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           573                             1                             2                           573                           574                           693                           694
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           574                             1                             2                           574                           575                           694                           695
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           575                             1                             2                           575                           576                           695                           696
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           576                             1                             2                           576                           577                           696                           697
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           577                             1                             2                           577                           578                           697                           698
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           578                             1                             2                           578                           579                           698                           699
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           579                             1                             2                           579                           580                           699                           700
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           580                             1                             2                           580                           581                           700                           701
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           581                             1                             2                           581                           582                           701                           702
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           582                             1                             2                           582                           583                           702                           703
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           583                             1                             2                           583                           584                           703                           704
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           584                             1                             2                           584                           585                           704                           705
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           585                             1                             2                           585                           586                           705                           706
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           586                             1                             2                           586                           587                           706                           707
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           587                             1                             2                           587                           588                           707                           708
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           588                             1                             2                           588                           589                           708                           709
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           589                             1                             2                           589                           590                           709                           710
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           590                             1                             2                           590                           591                           710                           711
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           591                             1                             2                           591                           592                           711                           712
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           592                             1                             2                           592                           593                           712                           713
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           593                             1                             2                           593                           594                           713                           714
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           594                             1                             2                           594                           595                           714                           715
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           595                             1                             2                           595                           596                           715                           716
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           596                             1                             2                           596                           597                           716                           717
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           597                             1                             2                           597                           598                           717                           718
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           598                             1                             2                           598                           599                           718                           719
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           599                             1                             2                           599                           600                           719                           720
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           600                             1                             2                           600                           481                           720                           601
  0.2179339429539087213961E-01  0.2375860203065026377001E-01
                           601                             1                             2                           601                           602                           721                           722
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           602                             1                             2                           602                           603                           722                           723
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           603                             1                             2                           603                           604                           723                           724
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           604                             1                             2                           604                           605                           724                           725
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           605                             1                             2                           605                           606                           725                           726
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           606                             1                             2                           606                           607                           726                           727
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           607                             1                             2                           607                           608                           727                           728
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           608                             1                             2                           608                           609                           728                           729
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           609                             1                             2                           609                           610                           729                           730
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           610                             1                             2                           610                           611                           730                           731
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           611                             1                             2                           611                           612                           731                           732
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           612                             1                             2                           612                           613                           732                           733
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           613                             1                             2                           613                           614                           733                           734
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           614                             1                             2                           614                           615                           734                           735
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           615                             1                             2                           615                           616                           735                           736
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           616                             1                             2                           616                           617                           736                           737
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           617                             1                             2                           617                           618                           737                           738
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           618                             1                             2                           618                           619                           738                           739
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           619                             1                             2                           619                           620                           739                           740
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           620                             1                             2                           620                           621                           740                           741
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           621                             1                             2                           621                           622                           741                           742
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           622                             1                             2                           622                           623                           742                           743
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           623                             1                             2                           623                           624                           743                           744
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           624                             1                             2                           624                           625                           744                           745
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           625                             1                             2                           625                           626                           745                           746
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           626                             1                             2                           626                           627                           746                           747
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           627                             1                             2                           627                           628                           747                           748
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           628                             1                             2                           628                           629                           748                           749
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           629                             1                             2                           629                           630                           749                           750
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           630                             1                             2                           630                           631                           750                           751
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           631                             1                             2                           631                           632                           751                           752
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           632                             1                             2                           632                           633                           752                           753
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           633                             1                             2                           633                           634                           753                           754
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           634                             1                             2                           634                           635                           754                           755
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           635                             1                             2                           635                           636                           755                           756
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           636                             1                             2                           636                           637                           756                           757
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           637                             1                             2                           637                           638                           757                           758
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           638                             1                             2                           638                           639                           758                           759
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           639                             1                             2                           639                           640                           759                           760
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           640                             1                             2                           640                           641                           760                           761
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           641                             1                             2                           641                           642                           761                           762
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           642                             1                             2                           642                           643                           762                           763
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           643                             1                             2                           643                           644                           763                           764
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           644                             1                             2                           644                           645                           764                           765
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           645                             1                             2                           645                           646                           765                           766
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           646                             1                             2                           646                           647                           766                           767
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           647                             1                             2                           647                           648                           767                           768
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           648                             1                             2                           648                           649                           768                           769
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           649                             1                             2                           649                           650                           769                           770
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           650                             1                             2                           650                           651                           770                           771
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           651                             1                             2                           651                           652                           771                           772
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           652                             1                             2                           652                           653                           772                           773
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           653                             1                             2                           653                           654                           773                           774
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           654                             1                             2                           654                           655                           774                           775
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           655                             1                             2                           655                           656                           775                           776
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           656                             1                             2                           656                           657                           776                           777
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           657                             1                             2                           657                           658                           777                           778
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           658                             1                             2                           658                           659                           778                           779
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           659                             1                             2                           659                           660                           779                           780
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           660                             1                             2                           660                           661                           780                           781
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           661                             1                             2                           661                           662                           781                           782
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           662                             1                             2                           662                           663                           782                           783
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           663                             1                             2                           663                           664                           783                           784
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           664                             1                             2                           664                           665                           784                           785
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           665                             1                             2                           665                           666                           785                           786
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           666                             1                             2                           666                           667                           786                           787
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           667                             1                             2                           667                           668                           787                           788
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           668                             1                             2                           668                           669                           788                           789
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           669                             1                             2                           669                           670                           789                           790
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           670                             1                             2                           670                           671                           790                           791
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           671                             1                             2                           671                           672                           791                           792
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           672                             1                             2                           672                           673                           792                           793
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           673                             1                             2                           673                           674                           793                           794
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           674                             1                             2                           674                           675                           794                           795
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           675                             1                             2                           675                           676                           795                           796
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           676                             1                             2                           676                           677                           796                           797
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           677                             1                             2                           677                           678                           797                           798
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           678                             1                             2                           678                           679                           798                           799
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           679                             1                             2                           679                           680                           799                           800
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           680                             1                             2                           680                           681                           800                           801
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           681                             1                             2                           681                           682                           801                           802
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           682                             1                             2                           682                           683                           802                           803
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           683                             1                             2                           683                           684                           803                           804
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           684                             1                             2                           684                           685                           804                           805
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           685                             1                             2                           685                           686                           805                           806
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           686                             1                             2                           686                           687                           806                           807
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           687                             1                             2                           687                           688                           807                           808
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           688                             1                             2                           688                           689                           808                           809
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           689                             1                             2                           689                           690                           809                           810
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           690                             1                             2                           690                           691                           810                           811
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           691                             1                             2                           691                           692                           811                           812
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           692                             1                             2                           692                           693                           812                           813
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           693                             1                             2                           693                           694                           813                           814
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           694                             1                             2                           694                           695                           814                           815
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           695                             1                             2                           695                           696                           815                           816
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           696                             1                             2                           696                           697                           816                           817
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           697                             1                             2                           697                           698                           817                           818
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           698                             1                             2                           698                           699                           818                           819
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           699                             1                             2                           699                           700                           819                           820
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           700                             1                             2                           700                           701                           820                           821
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           701                             1                             2                           701                           702                           821                           822
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           702                             1                             2                           702                           703                           822                           823
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           703                             1                             2                           703                           704                           823                           824
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           704                             1                             2                           704                           705                           824                           825
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           705                             1                             2                           705                           706                           825                           826
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           706                             1                             2                           706                           707                           826                           827
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           707                             1                             2                           707                           708                           827                           828
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           708                             1                             2                           708                           709                           828                           829
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           709                             1                             2                           709                           710                           829                           830
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           710                             1                             2                           710                           711                           830                           831
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           711                             1                             2                           711                           712                           831                           832
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           712                             1                             2                           712                           713                           832                           833
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           713                             1                             2                           713                           714                           833                           834
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           714                             1                             2                           714                           715                           834                           835
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           715                             1                             2                           715                           716                           835                           836
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           716                             1                             2                           716                           717                           836                           837
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           717                             1                             2                           717                           718                           837                           838
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           718                             1                             2                           718                           719                           838                           839
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           719                             1                             2                           719                           720                           839                           840
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           720                             1                             2                           720                           601                           840                           721
  0.2293582323282394169750E-01  0.2778396458607451310896E-01
                           721                             1                             3                           721                           722                           841                           842
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           722                             1                             3                           722                           723                           842                           843
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           723                             1                             3                           723                           724                           843                           844
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           724                             1                             3                           724                           725                           844                           845
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           725                             1                             3                           725                           726                           845                           846
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           726                             1                             3                           726                           727                           846                           847
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           727                             1                             3                           727                           728                           847                           848
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           728                             1                             3                           728                           729                           848                           849
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           729                             1                             3                           729                           730                           849                           850
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           730                             1                             3                           730                           731                           850                           851
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           731                             1                             3                           731                           732                           851                           852
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           732                             1                             3                           732                           733                           852                           853
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           733                             1                             3                           733                           734                           853                           854
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
                           734                             1                             3                           734                           735                           854                           855
  0.2383768722227580516559E-01  0.2497836844596585184619E-01
