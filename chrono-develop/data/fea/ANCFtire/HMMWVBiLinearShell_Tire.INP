 -0.1450534117442595916092E+00  0.1500082858941103047812E+00  0.8451770567314984550222E+00 -0.8737275147447152653934E-02 -0.9997027456229882202976E+00  0.2276137994183551754857E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2469                             0                             0                             0                             0                             0                             0
 -0.1646311781910458349465E+00  0.1500082858941103047812E+00  0.8370676803482666183953E+00 -0.9916539600182782202009E-02 -0.9997027456229882202976E+00  0.2227291261188793503045E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2470                             0                             0                             0                             0                             0                             0
 -0.1837577020217830980897E+00  0.1500082858941103047812E+00  0.8279447964554367267453E+00 -0.1106862350716451490196E-01 -0.9997027456229882202976E+00  0.2172339677664234663945E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2471                             0                             0                             0                             0                             0                             0
 -0.2023805587641199499327E+00  0.1500082858941103047812E+00  0.8178334102436347619047E+00 -0.1219036908648369645081E-01 -0.9997027456229882202976E+00  0.2111433862080677389961E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2472                             0                             0                             0                             0                             0                             0
 -0.2204487044621846469905E+00  0.1500082858941103047812E+00  0.8067612363196335900639E+00 -0.1327870171147900110742E-01 -0.9997027456229881092753E+00  0.2044740753045124967424E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2473                             0                             0                             0                             0                             0                             0
 -0.2379126155845199264149E+00  0.1500082858941103047812E+00  0.7947586227425416094405E+00 -0.1433063833807437376100E-01 -0.9997027456229881092753E+00  0.1972443151733663593839E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2474                             0                             0                             0                             0                             0                             0
 -0.2547244247646411885455E+00  0.1500082858941103047812E+00  0.7818584678418821765078E+00 -0.1534329568109554092770E-01 -0.9997027456229881092753E+00  0.1894739220846142907506E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2475                             0                             0                             0                             0                             0                             0
 -0.2708380520021603787839E+00  0.1500082858941103047812E+00  0.7680961300455591000969E+00 -0.1631389811715424145722E-01 -0.9997027456229883313199E+00  0.1811841941455990395715E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2476                             0                             0                             0                             0                             0                             0
 -0.2862093309648636729747E+00  0.1500082858941103047812E+00  0.7535093309648637216469E+00 -0.1723978529243896593015E-01 -0.9997027456229883313199E+00  0.1723978529243896939960E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2477                             0                             0                             0                             0                             0                             0
 -0.3007961300455589404024E+00  0.1500082858941103047812E+00  0.7381380520021603164338E+00 -0.1811841941455990048770E-01 -0.9997027456229881092753E+00  0.1631389811715424145722E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2478                             0                             0                             0                             0                             0                             0
 -0.3145584678418820168133E+00  0.1500082858941103047812E+00  0.7220244247646413482400E+00 -0.1894739220846141866672E-01 -0.9997027456229883313199E+00  0.1534329568109555307076E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2479                             0                             0                             0                             0                             0                             0
 -0.3274586227425416162795E+00  0.1500082858941103047812E+00  0.7052126155845199750871E+00 -0.1972443151733663246894E-01 -0.9997027456229881092753E+00  0.1433063833807437896517E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2480                             0                             0                             0                             0                             0                             0
 -0.3394612363196336524140E+00  0.1500082858941103047812E+00  0.6877487044621846123960E+00 -0.2044740753045125661314E-01 -0.9997027456229884423422E+00  0.1327870171147899763797E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2481                             0                             0                             0                             0                             0                             0
 -0.3505334102436346577214E+00  0.1500082858941103047812E+00  0.6696805587641201373827E+00 -0.2111433862080676696071E-01 -0.9997027456229883313199E+00  0.1219036908648371032859E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2482                             0                             0                             0                             0                             0                             0
 -0.3606447964554366225620E+00  0.1500082858941103047812E+00  0.6510577020217831467619E+00 -0.2172339677664234317001E-01 -0.9997027456229881092753E+00  0.1106862350716451837140E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2483                             0                             0                             0                             0                             0                             0
 -0.3697676803482665142120E+00  0.1500082858941103047812E+00  0.6319311781910460501521E+00 -0.2227291261188792809156E-01 -0.9997027456229882202976E+00  0.9916539600182794345073E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2484                             0                             0                             0                             0                             0                             0
 -0.3778770567314984618612E+00  0.1500082858941103047812E+00  0.6123534117442595015035E+00 -0.2276137994183552101801E-01 -0.9997027456229883313199E+00  0.8737275147447147449764E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2485                             0                             0                             0                             0                             0                             0
 -0.3849506983681412197740E+00  0.1500082858941103047812E+00  0.5923780639784216317523E+00 -0.2318745991148664364889E-01 -0.9997027456229882202976E+00  0.7534062430852936018133E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2486                             0                             0                             0                             0                             0                             0
 -0.3909692168981519500015E+00  0.1500082858941103047812E+00  0.5720598859332881591655E+00 -0.2354998466526096734253E-01 -0.9997027456229882202976E+00  0.6310199372821995340843E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2487                             0                             0                             0                             0                             0                             0
 -0.3959161159805819063529E+00  0.1500082858941103047812E+00  0.5514545683225823280438E+00 -0.2384796054800717227118E-01 -0.9997027456229882202976E+00  0.5069040496926750967444E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2488                             0                             0                             0                             0                             0                             0
 -0.3997778365089009189326E+00  0.1500082858941103047812E+00  0.5306185888896163271866E+00 -0.2408057082854270225525E-01 -0.9997027456229881092753E+00  0.3813987733374094111355E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2489                             0                             0                             0                             0                             0                             0
 -0.4025437937755657613614E+00  0.1500082858941103047812E+00  0.5096090576057252796716E+00 -0.2424717793825715422829E-01 -0.9997027456229882202976E+00  0.2548481094551317306662E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2490                             0                             0                             0                             0                             0                             0
 -0.4042064064839678283469E+00  0.1500082858941103047812E+00  0.4884835601358027967756E+00 -0.2434732521864351947882E-01 -0.9997027456229883313199E+00  0.1275989246191080919018E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2491                             0                             0                             0                             0                             0                             0
 -0.4047611175282400663988E+00  0.1500082858941103047812E+00  0.4673000000000000486722E+00 -0.2438073817296740330995E-01 -0.9997027456229882202976E+00  0.2985779296437421979845E-17
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2492                             0                             0                             0                             0                             0                             0
 -0.4042064064839677728358E+00  0.1500082858941103047812E+00  0.4461164398641969119907E+00 -0.2434732521864351600938E-01 -0.9997027456229882202976E+00 -0.1275989246191096531530E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2493                             0                             0                             0                             0                             0                             0
 -0.4025437937755657613614E+00  0.1500082858941103047812E+00  0.4249909423942751507397E+00 -0.2424717793825715769773E-01 -0.9997027456229882202976E+00 -0.2548481094551289984768E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2494                             0                             0                             0                             0                             0                             0
 -0.3997778365089009744437E+00  0.1500082858941103047812E+00  0.4039814111103837701577E+00 -0.2408057082854270572470E-01 -0.9997027456229882202976E+00 -0.3813987733374088039823E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2495                             0                             0                             0                             0                             0                             0
 -0.3959161159805819063529E+00  0.1500082858941103047812E+00  0.3831454316774177137894E+00 -0.2384796054800717227118E-01 -0.9997027456229881092753E+00 -0.5069040496926745763273E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2496                             0                             0                             0                             0                             0                             0
 -0.3909692168981519500015E+00  0.1500082858941103047812E+00  0.3625401140667115496008E+00 -0.2354998466526096734253E-01 -0.9997027456229883313199E+00 -0.6310199372822010085993E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2497                             0                             0                             0                             0                             0                             0
 -0.3849506983681412197740E+00  0.1500082858941103047812E+00  0.3422219360215784655921E+00 -0.2318745991148664711834E-01 -0.9997027456229883313199E+00 -0.7534062430852930813963E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2498                             0                             0                             0                             0                             0                             0
 -0.3778770567314984618612E+00  0.1500082858941103047812E+00  0.3222465882557405958408E+00 -0.2276137994183552101801E-01 -0.9997027456229881092753E+00 -0.8737275147447142245594E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2499                             0                             0                             0                             0                             0                             0
 -0.3697676803482667362566E+00  0.1500082858941103047812E+00  0.3026688218089543802591E+00 -0.2227291261188794196935E-01 -0.9997027456229882202976E+00 -0.9916539600182770058945E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2500                             0                             0                             0                             0                             0                             0
 -0.3606447964554366780732E+00  0.1500082858941103047812E+00  0.2835422979782168950713E+00 -0.2172339677664234663945E-01 -0.9997027456229882202976E+00 -0.1106862350716451490196E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2501                             0                             0                             0                             0                             0                             0
 -0.3505334102436347132326E+00  0.1500082858941103047812E+00  0.2649194412358799044505E+00 -0.2111433862080677043016E-01 -0.9997027456229883313199E+00 -0.1219036908648370512442E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2502                             0                             0                             0                             0                             0                             0
 -0.3394612363196337079252E+00  0.1500082858941103047812E+00  0.2468512955378154849484E+00 -0.2044740753045125661314E-01 -0.9997027456229883313199E+00 -0.1327870171147899243380E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2503                             0                             0                             0                             0                             0                             0
 -0.3274586227425416717907E+00  0.1500082858941103047812E+00  0.2293873844154800667461E+00 -0.1972443151733663940783E-01 -0.9997027456229883313199E+00 -0.1433063833807437376100E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2504                             0                             0                             0                             0                             0                             0
 -0.3145584678418822943691E+00  0.1500082858941103047812E+00  0.2125755752353589711490E+00 -0.1894739220846143601396E-01 -0.9997027456229881092753E+00 -0.1534329568109553051936E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2505                             0                             0                             0                             0                             0                             0
 -0.3007961300455588848912E+00  0.1500082858941103047812E+00  0.1964619479978395033548E+00 -0.1811841941455989701826E-01 -0.9997027456229881092753E+00 -0.1631389811715424839611E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2506                             0                             0                             0                             0                             0                             0
 -0.2862093309648637839970E+00  0.1500082858941103047812E+00  0.1810906690351363201863E+00 -0.1723978529243897286904E-01 -0.9997027456229884423422E+00 -0.1723978529243896593015E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2507                             0                             0                             0                             0                             0                             0
 -0.2708380520021603232728E+00  0.1500082858941103047812E+00  0.1665038699544409417364E+00 -0.1631389811715423798777E-01 -0.9997027456229882202976E+00 -0.1811841941455990742660E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2508                             0                             0                             0                             0                             0                             0
 -0.2547244247646414105901E+00  0.1500082858941103047812E+00  0.1527415321581179763477E+00 -0.1534329568109555480548E-01 -0.9997027456229882202976E+00 -0.1894739220846141519727E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2509                             0                             0                             0                             0                             0                             0
 -0.2379126155845200096817E+00  0.1500082858941103047812E+00  0.1398413772574583768815E+00 -0.1433063833807437896517E-01 -0.9997027456229881092753E+00 -0.1972443151733663246894E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2510                             0                             0                             0                             0                             0                             0
 -0.2204487044621848967907E+00  0.1500082858941103047812E+00  0.1278387636803665627916E+00 -0.1327870171147901671993E-01 -0.9997027456229883313199E+00 -0.2044740753045124273535E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2511                             0                             0                             0                             0                             0                             0
 -0.2023805587641198666660E+00  0.1500082858941103047812E+00  0.1167665897563651689062E+00 -0.1219036908648369298136E-01 -0.9997027456229881092753E+00 -0.2111433862080677736905E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2512                             0                             0                             0                             0                             0                             0
 -0.1837577020217831813564E+00  0.1500082858941103047812E+00  0.1066552035445633705990E+00 -0.1106862350716452010613E-01 -0.9997027456229882202976E+00 -0.2172339677664234317001E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2513                             0                             0                             0                             0                             0                             0
 -0.1646311781910457516798E+00  0.1500082858941103047812E+00  0.9753231965173331241559E-01 -0.9916539600182776997839E-02 -0.9997027456229882202976E+00 -0.2227291261188793849990E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2514                             0                             0                             0                             0                             0                             0
 -0.1450534117442598691650E+00  0.1500082858941103047812E+00  0.8942294326850169783327E-01 -0.8737275147447170001169E-02 -0.9997027456229883313199E+00 -0.2276137994183551407912E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2515                             0                             0                             0                             0                             0                             0
 -0.1250780639784216385912E+00  0.1500082858941103047812E+00  0.8234930163185877338705E-01 -0.7534062430852937752856E-02 -0.9997027456229883313199E+00 -0.2318745991148664364889E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2516                             0                             0                             0                             0                             0                             0
 -0.1047598859332882215156E+00  0.1500082858941103047812E+00  0.7633078310184804315952E-01 -0.6310199372821997075567E-02 -0.9997027456229882202976E+00 -0.2354998466526096734253E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2517                             0                             0                             0                             0                             0                             0
 -0.8415456832258202957142E-01  0.1500082858941103047812E+00  0.7138388401941803129702E-01 -0.5069040496926731018124E-02 -0.9997027456229881092753E+00 -0.2384796054800717574063E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2518                             0                             0                             0                             0                             0                             0
 -0.6331858888961632014780E-01  0.1500082858941103047812E+00  0.6752216349109907422843E-01 -0.3813987733374095412398E-02 -0.9997027456229881092753E+00 -0.2408057082854270225525E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2519                             0                             0                             0                             0                             0                             0
 -0.4230905760572496732141E-01  0.1500082858941103047812E+00  0.6475620622443423179959E-01 -0.2548481094551297357342E-02 -0.9997027456229882202976E+00 -0.2424717793825715769773E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2520                             0                             0                             0                             0                             0                             0
 -0.2118356013580320953982E-01  0.1500082858941103047812E+00  0.6309359351603222032523E-01 -0.1275989246191103904104E-02 -0.9997027456229882202976E+00 -0.2434732521864351600938E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2521                             0                             0                             0                             0                             0                             0
  0.2267905928450650471371E-16  0.1454899278495849213044E+00  0.9692285451941656804209E-01  0.1339179490475880993808E-16 -0.9757911121022321276897E+00 -0.2187046079585183155913E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2522                             0                             0                             0                             0                             0                             0
  0.1938404207925830541326E-01  0.1454899278495849213044E+00  0.9743044352499785620836E-01  0.1144611479224722991321E-01 -0.9757911121022320166674E+00 -0.2184048808942966046764E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2523                             0                             0                             0                             0                             0                             0
  0.3871495384654550370174E-01  0.1454899278495849213044E+00  0.9895181927555946055364E-01  0.2286085657945853208406E-01 -0.9757911121022320166674E+00 -0.2175065212326807717602E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2524                             0                             0                             0                             0                             0                             0
  0.5793975061638285267707E-01  0.1454899278495849213044E+00  0.1014828117859186140670E+00  0.3421293834782424686525E-01 -0.9757911121022322387120E+00 -0.2160119913150591042239E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2525                             0                             0                             0                             0                             0                             0
  0.7700573855712337933976E-01  0.1454899278495849213044E+00  0.1050164837815316665193E+00  0.4547124483029075375784E-01 -0.9757911121022321276897E+00 -0.2139253875440522423279E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2526                             0                             0                             0                             0                             0                             0
  0.9586065912108200637309E-01  0.1454899278495849213044E+00  0.1095431497130809894713E+00  0.5660491779134486922676E-01 -0.9757911121022321276897E+00 -0.2112524291555585576052E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2527                             0                             0                             0                             0                             0                             0
  0.1144528322815825394088E+00  0.1454899278495849213044E+00  0.1150504023038930734302E+00  0.6758344060729254421105E-01 -0.9757911121022320166674E+00 -0.2080004425427257330750E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2528                             0                             0                             0                             0                             0                             0
  0.1327312981843180861308E+00  0.1454899278495849213044E+00  0.1215231465574208025160E+00  0.7837672191020299272690E-01 -0.9757911121022322387120E+00 -0.2041783411748168408639E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2529                             0                             0                             0                             0                             0                             0
  0.1506459568247697777821E+00  0.1454899278495849213044E+00  0.1289436411315802444300E+00  0.8895517806625667656117E-01 -0.9757911121022321276897E+00 -0.1997966011660102236824E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2530                             0                             0                             0                             0                             0                             0
  0.1681477053688368861195E+00  0.1454899278495849213044E+00  0.1372915469665359489149E+00  0.9928981426242940167004E-01 -0.9757911121022320166674E+00 -0.1948672325610990574418E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2531                             0                             0                             0                             0                             0                             0
  0.1851885727402916848039E+00  0.1454899278495849213044E+00  0.1465439830326499270896E+00  0.1093523039792591300401E+00 -0.9757911121022321276897E+00 -0.1894037464167931950065E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2532                             0                             0                             0                             0                             0                             0
  0.2017218511061652508332E+00  0.1454899278495849213044E+00  0.1566755890457941502447E+00  0.1191150666318672307620E+00 -0.9757911121022321276897E+00 -0.1834211177688518656925E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2533                             0                             0                             0                             0                             0                             0
  0.2177022238996707548253E+00  0.1454899278495849213044E+00  0.1676585949781257411928E+00  0.1285513431664241090768E+00 -0.9757911121022322387120E+00 -0.1769357445865517020067E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2534                             0                             0                             0                             0                             0                             0
  0.2330858900297633207188E+00  0.1454899278495849213044E+00  0.1794628971738036482542E+00  0.1376352694048561531304E+00 -0.9757911121022320166674E+00 -0.1699654028269925731820E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2535                             0                             0                             0                             0                             0                             0
  0.2478306839368858427441E+00  0.1454899278495849213044E+00  0.1920561408610164111366E+00  0.1463419469367597258724E+00 -0.9757911121022320166674E+00 -0.1625291977124349862560E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2536                             0                             0                             0                             0                             0                             0
  0.2618961911658369556832E+00  0.1454899278495849213044E+00  0.2054038088341629819666E+00  0.1546475113642136467451E+00 -0.9757911121022322387120E+00 -0.1546475113642136745007E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2537                             0                             0                             0                             0                             0                             0
  0.2752438591389836375356E+00  0.1454899278495849213044E+00  0.2194693160631141504169E+00  0.1625291977124350140116E+00 -0.9757911121022322387120E+00 -0.1463419469367597258724E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2538                             0                             0                             0                             0                             0                             0
  0.2878371028261964004180E+00  0.1454899278495849213044E+00  0.2342141099702367279534E+00  0.1699654028269926009376E+00 -0.9757911121022320166674E+00 -0.1376352694048561253748E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2539                             0                             0                             0                             0                             0                             0
  0.2996414050218742519682E+00  0.1454899278495849213044E+00  0.2495977761003292383357E+00  0.1769357445865517020067E+00 -0.9757911121022322387120E+00 -0.1285513431664241090768E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2540                             0                             0                             0                             0                             0                             0
  0.3106244109542058429163E+00  0.1454899278495849213044E+00  0.2655781488938347423279E+00  0.1834211177688518656925E+00 -0.9757911121022321276897E+00 -0.1191150666318672307620E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2541                             0                             0                             0                             0                             0                             0
  0.3207560169673500105603E+00  0.1454899278495849213044E+00  0.2821114272597082806016E+00  0.1894037464167931672510E+00 -0.9757911121022320166674E+00 -0.1093523039792591577957E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2542                             0                             0                             0                             0                             0                             0
  0.3300084530334640997573E+00  0.1454899278495849213044E+00  0.2991522946311631070415E+00  0.1948672325610990574418E+00 -0.9757911121022320166674E+00 -0.9928981426242938779225E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2543                             0                             0                             0                             0                             0                             0
  0.3383563588684197487311E+00  0.1454899278495849213044E+00  0.3166540431752301598678E+00  0.1997966011660102236824E+00 -0.9757911121022322387120E+00 -0.8895517806625670431675E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2544                             0                             0                             0                             0                             0                             0
  0.3457768534425791906450E+00  0.1454899278495849213044E+00  0.3345687018156818792747E+00  0.2041783411748168408639E+00 -0.9757911121022321276897E+00 -0.7837672191020297884911E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2545                             0                             0                             0                             0                             0                             0
  0.3522495976961069197309E+00  0.1454899278495849213044E+00  0.3528471677184174537523E+00  0.2080004425427257330750E+00 -0.9757911121022320166674E+00 -0.6758344060729253033326E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2546                             0                             0                             0                             0                             0                             0
  0.3577568502869190036897E+00  0.1454899278495849213044E+00  0.3714393408789180006657E+00  0.2112524291555585576052E+00 -0.9757911121022321276897E+00 -0.5660491779134485534897E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2547                             0                             0                             0                             0                             0                             0
  0.3622835162184683821529E+00  0.1454899278495849213044E+00  0.3902942614428767109658E+00  0.2139253875440522700835E+00 -0.9757911121022322387120E+00 -0.4547124483029069130779E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2548                             0                             0                             0                             0                             0                             0
  0.3658171882140813790940E+00  0.1454899278495849213044E+00  0.4093602493836171474229E+00  0.2160119913150591042239E+00 -0.9757911121022322387120E+00 -0.3421293834782423298746E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2549                             0                             0                             0                             0                             0                             0
  0.3683481807244405326074E+00  0.1454899278495849213044E+00  0.4285850461534544963982E+00  0.2175065212326807717602E+00 -0.9757911121022320166674E+00 -0.2286085657945851820627E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2550                             0                             0                             0                             0                             0                             0
  0.3698695564750021369527E+00  0.1454899278495849213044E+00  0.4479159579207417918312E+00  0.2184048808942966046764E+00 -0.9757911121022319056451E+00 -0.1144611479224716746317E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2551                             0                             0                             0                             0                             0                             0
  0.3703771454805834251189E+00  0.1454899278495849213044E+00  0.4672999999999999376499E+00  0.2187046079585183155913E+00 -0.9757911121022321276897E+00 -0.4856217826943305739625E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2552                             0                             0                             0                             0                             0                             0
  0.3698695564750021369527E+00  0.1454899278495849213044E+00  0.4866840420792581944909E+00  0.2184048808942966046764E+00 -0.9757911121022319056451E+00  0.1144611479224716746317E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2553                             0                             0                             0                             0                             0                             0
  0.3683481807244405326074E+00  0.1454899278495849213044E+00  0.5060149538465454899239E+00  0.2175065212326807717602E+00 -0.9757911121022320166674E+00  0.2286085657945851820627E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2554                             0                             0                             0                             0                             0                             0
  0.3658171882140813790940E+00  0.1454899278495849213044E+00  0.5252397506163828388992E+00  0.2160119913150591042239E+00 -0.9757911121022322387120E+00  0.3421293834782423298746E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2555                             0                             0                             0                             0                             0                             0
  0.3622835162184683266418E+00  0.1454899278495849213044E+00  0.5443057385571233863786E+00  0.2139253875440522423279E+00 -0.9757911121022320166674E+00  0.4547124483029073988005E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2556                             0                             0                             0                             0                             0                             0
  0.3577568502869190036897E+00  0.1454899278495849213044E+00  0.5631606591210820411675E+00  0.2112524291555585576052E+00 -0.9757911121022321276897E+00  0.5660491779134485534897E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2557                             0                             0                             0                             0                             0                             0
  0.3522495976961069197309E+00  0.1454899278495849213044E+00  0.5817528322815824770586E+00  0.2080004425427257330750E+00 -0.9757911121022320166674E+00  0.6758344060729253033326E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2558                             0                             0                             0                             0                             0                             0
  0.3457768534425791906450E+00  0.1454899278495849213044E+00  0.6000312981843181070474E+00  0.2041783411748168408639E+00 -0.9757911121022321276897E+00  0.7837672191020297884911E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2559                             0                             0                             0                             0                             0                             0
  0.3383563588684198042422E+00  0.1454899278495849213044E+00  0.6179459568247698264543E+00  0.1997966011660102514380E+00 -0.9757911121022322387120E+00  0.8895517806625666268339E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2560                             0                             0                             0                             0                             0                             0
  0.3300084530334640997573E+00  0.1454899278495849213044E+00  0.6354477053688368792805E+00  0.1948672325610990574418E+00 -0.9757911121022320166674E+00  0.9928981426242938779225E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2561                             0                             0                             0                             0                             0                             0
  0.3207560169673500660714E+00  0.1454899278495849213044E+00  0.6524885727402915946982E+00  0.1894037464167931950065E+00 -0.9757911121022321276897E+00  0.1093523039792591161623E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2562                             0                             0                             0                             0                             0                             0
  0.3106244109542058984275E+00  0.1454899278495849213044E+00  0.6690218511061651884830E+00  0.1834211177688518934481E+00 -0.9757911121022320166674E+00  0.1191150666318671752508E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2563                             0                             0                             0                             0                             0                             0
  0.2996414050218742519682E+00  0.1454899278495849213044E+00  0.6850022238996706924752E+00  0.1769357445865517020067E+00 -0.9757911121022322387120E+00  0.1285513431664241090768E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2564                             0                             0                             0                             0                             0                             0
  0.2878371028261964559292E+00  0.1454899278495849213044E+00  0.7003858900297632583687E+00  0.1699654028269926286931E+00 -0.9757911121022322387120E+00  0.1376352694048560976192E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2565                             0                             0                             0                             0                             0                             0
  0.2752438591389836930468E+00  0.1454899278495849213044E+00  0.7151306839368857248829E+00  0.1625291977124350695227E+00 -0.9757911121022322387120E+00  0.1463419469367596981169E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2566                             0                             0                             0                             0                             0                             0
  0.2618961911658370111944E+00  0.1454899278495849213044E+00  0.7291961911658368933331E+00  0.1546475113642136745007E+00 -0.9757911121022322387120E+00  0.1546475113642136467451E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2567                             0                             0                             0                             0                             0                             0
  0.2478306839368858704997E+00  0.1454899278495849213044E+00  0.7425438591389835751855E+00  0.1463419469367597536280E+00 -0.9757911121022321276897E+00  0.1625291977124349862560E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2568                             0                             0                             0                             0                             0                             0
  0.2330858900297632652077E+00  0.1454899278495849213044E+00  0.7551371028261963935790E+00  0.1376352694048561253748E+00 -0.9757911121022320166674E+00  0.1699654028269926009376E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2569                             0                             0                             0                             0                             0                             0
  0.2177022238996707548253E+00  0.1454899278495849213044E+00  0.7669414050218742451293E+00  0.1285513431664241090768E+00 -0.9757911121022322387120E+00  0.1769357445865517020067E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2570                             0                             0                             0                             0                             0                             0
  0.2017218511061653063443E+00  0.1454899278495849213044E+00  0.7779244109542058360773E+00  0.1191150666318672585176E+00 -0.9757911121022321276897E+00  0.1834211177688518379369E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2571                             0                             0                             0                             0                             0                             0
  0.1851885727402916848039E+00  0.1454899278495849213044E+00  0.7880560169673500592324E+00  0.1093523039792591300401E+00 -0.9757911121022321276897E+00  0.1894037464167931950065E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2572                             0                             0                             0                             0                             0                             0
  0.1681477053688368861195E+00  0.1454899278495849213044E+00  0.7973084530334639818960E+00  0.9928981426242940167004E-01 -0.9757911121022320166674E+00  0.1948672325610990574418E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2573                             0                             0                             0                             0                             0                             0
  0.1506459568247696945154E+00  0.1454899278495849213044E+00  0.8056563588684197974032E+00  0.8895517806625663492781E-01 -0.9757911121022320166674E+00  0.1997966011660102514380E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2574                             0                             0                             0                             0                             0                             0
  0.1327312981843180306196E+00  0.1454899278495849213044E+00  0.8130768534425791838061E+00  0.7837672191020293721575E-01 -0.9757911121022320166674E+00  0.2041783411748168408639E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2575                             0                             0                             0                             0                             0                             0
  0.1144528322815825394088E+00  0.1454899278495849213044E+00  0.8195495976961069128919E+00  0.6758344060729254421105E-01 -0.9757911121022320166674E+00  0.2080004425427257330750E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2576                             0                             0                             0                             0                             0                             0
  0.9586065912108192310637E-01  0.1454899278495849213044E+00  0.8250568502869189968507E+00  0.5660491779134482065450E-01 -0.9757911121022320166674E+00  0.2112524291555585576052E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2577                             0                             0                             0                             0                             0                             0
  0.7700573855712329607304E-01  0.1454899278495849213044E+00  0.8295835162184683753139E+00  0.4547124483029070518558E-01 -0.9757911121022322387120E+00  0.2139253875440522700835E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2578                             0                             0                             0                             0                             0                             0
  0.5793975061638285267707E-01  0.1454899278495849213044E+00  0.8331171882140813167439E+00  0.3421293834782424686525E-01 -0.9757911121022322387120E+00  0.2160119913150591042239E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2579                             0                             0                             0                             0                             0                             0
  0.3871495384654542043501E-01  0.1454899278495849213044E+00  0.8356481807244405812796E+00  0.2286085657945848351180E-01 -0.9757911121022322387120E+00  0.2175065212326807995158E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2580                             0                             0                             0                             0                             0                             0
  0.1938404207925822214653E-01  0.1454899278495849213044E+00  0.8371695564750021301137E+00  0.1144611479224718134096E-01 -0.9757911121022319056451E+00  0.2184048808942966046764E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2581                             0                             0                             0                             0                             0                             0
  0.1871595531675004973344E-15  0.1454899278495849213044E+00  0.8376771454805833627688E+00  0.1105161514436249324343E-15 -0.9757911121022321276897E+00  0.2187046079585183155913E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2582                             0                             0                             0                             0                             0                             0
 -0.1938404207925817704372E-01  0.1454899278495849213044E+00  0.8371695564750021301137E+00 -0.1144611479224715358538E-01 -0.9757911121022319056451E+00  0.2184048808942966046764E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2583                             0                             0                             0                             0                             0                             0
 -0.3871495384654537880165E-01  0.1454899278495849213044E+00  0.8356481807244405812796E+00 -0.2286085657945845575623E-01 -0.9757911121022321276897E+00  0.2175065212326807995158E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2584                             0                             0                             0                             0                             0                             0
 -0.5793975061638281104370E-01  0.1454899278495849213044E+00  0.8331171882140813167439E+00 -0.3421293834782421910967E-01 -0.9757911121022322387120E+00  0.2160119913150591042239E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2585                             0                             0                             0                             0                             0                             0
 -0.7700573855712325443967E-01  0.1454899278495849213044E+00  0.8295835162184683753139E+00 -0.4547124483029067743001E-01 -0.9757911121022321276897E+00  0.2139253875440522700835E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2586                             0                             0                             0                             0                             0                             0
 -0.9586065912108188147300E-01  0.1454899278495849213044E+00  0.8250568502869191078730E+00 -0.5660491779134479289892E-01 -0.9757911121022322387120E+00  0.2112524291555585853608E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2587                             0                             0                             0                             0                             0                             0
 -0.1144528322815824977754E+00  0.1454899278495849213044E+00  0.8195495976961069128919E+00 -0.6758344060729251645547E-01 -0.9757911121022322387120E+00  0.2080004425427257608305E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2588                             0                             0                             0                             0                             0                             0
 -0.1327312981843179751085E+00  0.1454899278495849213044E+00  0.8130768534425791838061E+00 -0.7837672191020292333796E-01 -0.9757911121022320166674E+00  0.2041783411748168686195E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2589                             0                             0                             0                             0                             0                             0
 -0.1506459568247698055377E+00  0.1454899278495849213044E+00  0.8056563588684197974032E+00 -0.8895517806625669043896E-01 -0.9757911121022322387120E+00  0.1997966011660102236824E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2590                             0                             0                             0                             0                             0                             0
 -0.1681477053688368583639E+00  0.1454899278495849213044E+00  0.7973084530334640929183E+00 -0.9928981426242937391446E-01 -0.9757911121022320166674E+00  0.1948672325610990574418E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2591                             0                             0                             0                             0                             0                             0
 -0.1851885727402916292927E+00  0.1454899278495849213044E+00  0.7880560169673500592324E+00 -0.1093523039792591161623E+00 -0.9757911121022320166674E+00  0.1894037464167931950065E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2592                             0                             0                             0                             0                             0                             0
 -0.2017218511061652508332E+00  0.1454899278495849213044E+00  0.7779244109542058360773E+00 -0.1191150666318672307620E+00 -0.9757911121022320166674E+00  0.1834211177688518379369E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2593                             0                             0                             0                             0                             0                             0
 -0.2177022238996707270697E+00  0.1454899278495849213044E+00  0.7669414050218742451293E+00 -0.1285513431664240813213E+00 -0.9757911121022320166674E+00  0.1769357445865517020067E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2594                             0                             0                             0                             0                             0                             0
 -0.2330858900297632374521E+00  0.1454899278495849213044E+00  0.7551371028261963935790E+00 -0.1376352694048560976192E+00 -0.9757911121022322387120E+00  0.1699654028269926286931E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2595                             0                             0                             0                             0                             0                             0
 -0.2478306839368858427441E+00  0.1454899278495849213044E+00  0.7425438591389836862078E+00 -0.1463419469367597258724E+00 -0.9757911121022322387120E+00  0.1625291977124350140116E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2596                             0                             0                             0                             0                             0                             0
 -0.2618961911658369556832E+00  0.1454899278495849213044E+00  0.7291961911658370043554E+00 -0.1546475113642136467451E+00 -0.9757911121022322387120E+00  0.1546475113642136745007E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2597                             0                             0                             0                             0                             0                             0
 -0.2752438591389835265133E+00  0.1454899278495849213044E+00  0.7151306839368858359052E+00 -0.1625291977124349862560E+00 -0.9757911121022320166674E+00  0.1463419469367597536280E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2598                             0                             0                             0                             0                             0                             0
 -0.2878371028261962893957E+00  0.1454899278495849213044E+00  0.7003858900297633693910E+00 -0.1699654028269925454264E+00 -0.9757911121022321276897E+00  0.1376352694048562086415E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2599                             0                             0                             0                             0                             0                             0
 -0.2996414050218741964571E+00  0.1454899278495849213044E+00  0.6850022238996708034975E+00 -0.1769357445865516742511E+00 -0.9757911121022321276897E+00  0.1285513431664241368324E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2600                             0                             0                             0                             0                             0                             0
 -0.3106244109542058984275E+00  0.1454899278495849213044E+00  0.6690218511061651884830E+00 -0.1834211177688518934481E+00 -0.9757911121022322387120E+00  0.1191150666318672030064E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2601                             0                             0                             0                             0                             0                             0
 -0.3207560169673499550491E+00  0.1454899278495849213044E+00  0.6524885727402918167428E+00 -0.1894037464167931394954E+00 -0.9757911121022322387120E+00  0.1093523039792592271846E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2602                             0                             0                             0                             0                             0                             0
 -0.3300084530334640442462E+00  0.1454899278495849213044E+00  0.6354477053688368792805E+00 -0.1948672325610990574418E+00 -0.9757911121022320166674E+00  0.9928981426242940167004E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2603                             0                             0                             0                             0                             0                             0
 -0.3383563588684196377088E+00  0.1454899278495849213044E+00  0.6179459568247700484989E+00 -0.1997966011660101681713E+00 -0.9757911121022322387120E+00  0.8895517806625681533905E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2604                             0                             0                             0                             0                             0                             0
 -0.3457768534425793016673E+00  0.1454899278495849213044E+00  0.6000312981843178850028E+00 -0.2041783411748168686195E+00 -0.9757911121022321276897E+00  0.7837672191020286782681E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2605                             0                             0                             0                             0                             0                             0
 -0.3522495976961069197309E+00  0.1454899278495849213044E+00  0.5817528322815825880809E+00 -0.2080004425427257330750E+00 -0.9757911121022321276897E+00  0.6758344060729255808884E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2606                             0                             0                             0                             0                             0                             0
 -0.3577568502869190036897E+00  0.1454899278495849213044E+00  0.5631606591210819301452E+00 -0.2112524291555585576052E+00 -0.9757911121022321276897E+00  0.5660491779134483453229E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2607                             0                             0                             0                             0                             0                             0
 -0.3622835162184683266418E+00  0.1454899278495849213044E+00  0.5443057385571234974009E+00 -0.2139253875440522423279E+00 -0.9757911121022322387120E+00  0.4547124483029081620789E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2608                             0                             0                             0                             0                             0                             0
 -0.3658171882140813235829E+00  0.1454899278495849213044E+00  0.5252397506163828388992E+00 -0.2160119913150591042239E+00 -0.9757911121022320166674E+00  0.3421293834782425380414E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2609                             0                             0                             0                             0                             0                             0
 -0.3683481807244405326074E+00  0.1454899278495849213044E+00  0.5060149538465457119685E+00 -0.2175065212326807717602E+00 -0.9757911121022321276897E+00  0.2286085657945868820917E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2610                             0                             0                             0                             0                             0                             0
 -0.3698695564750021924638E+00  0.1454899278495849213044E+00  0.4866840420792580834686E+00 -0.2184048808942966324320E+00 -0.9757911121022321276897E+00  0.1144611479224709807423E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2611                             0                             0                             0                             0                             0                             0
 -0.3703771454805834251189E+00  0.1454899278495849213044E+00  0.4673000000000000486722E+00 -0.2187046079585183155913E+00 -0.9757911121022321276897E+00  0.2678358980951761987616E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2612                             0                             0                             0                             0                             0                             0
 -0.3698695564750021369527E+00  0.1454899278495849213044E+00  0.4479159579207416808089E+00 -0.2184048808942966046764E+00 -0.9757911121022320166674E+00 -0.1144611479224723685211E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2613                             0                             0                             0                             0                             0                             0
 -0.3683481807244405881185E+00  0.1454899278495849213044E+00  0.4285850461534546074205E+00 -0.2175065212326807995158E+00 -0.9757911121022321276897E+00 -0.2286085657945844534789E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2614                             0                             0                             0                             0                             0                             0
 -0.3658171882140813790940E+00  0.1454899278495849213044E+00  0.4093602493836172029340E+00 -0.2160119913150591042239E+00 -0.9757911121022321276897E+00 -0.3421293834782419829299E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2615                             0                             0                             0                             0                             0                             0
 -0.3622835162184683266418E+00  0.1454899278495849213044E+00  0.3902942614428765999435E+00 -0.2139253875440522423279E+00 -0.9757911121022321276897E+00 -0.4547124483029076763563E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2616                             0                             0                             0                             0                             0                             0
 -0.3577568502869189481785E+00  0.1454899278495849213044E+00  0.3714393408789178341323E+00 -0.2112524291555585298497E+00 -0.9757911121022321276897E+00 -0.5660491779134496637127E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2617                             0                             0                             0                             0                             0                             0
 -0.3522495976961069752420E+00  0.1454899278495849213044E+00  0.3528471677184175092634E+00 -0.2080004425427257608305E+00 -0.9757911121022321276897E+00 -0.6758344060729250257769E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2618                             0                             0                             0                             0                             0                             0
 -0.3457768534425793016673E+00  0.1454899278495849213044E+00  0.3345687018156822123416E+00 -0.2041783411748168686195E+00 -0.9757911121022320166674E+00 -0.7837672191020282619345E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2619                             0                             0                             0                             0                             0                             0
 -0.3383563588684198042422E+00  0.1454899278495849213044E+00  0.3166540431752303819124E+00 -0.1997966011660102791936E+00 -0.9757911121022320166674E+00 -0.8895517806625659329445E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2620                             0                             0                             0                             0                             0                             0
 -0.3300084530334640997573E+00  0.1454899278495849213044E+00  0.2991522946311631070415E+00 -0.1948672325610990574418E+00 -0.9757911121022320166674E+00 -0.9928981426242937391446E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2621                             0                             0                             0                             0                             0                             0
 -0.3207560169673500105603E+00  0.1454899278495849213044E+00  0.2821114272597082806016E+00 -0.1894037464167931672510E+00 -0.9757911121022321276897E+00 -0.1093523039792591855512E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2622                             0                             0                             0                             0                             0                             0
 -0.3106244109542059539386E+00  0.1454899278495849213044E+00  0.2655781488938348533502E+00 -0.1834211177688519212037E+00 -0.9757911121022322387120E+00 -0.1191150666318671613730E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2623                             0                             0                             0                             0                             0                             0
 -0.2996414050218743074794E+00  0.1454899278495849213044E+00  0.2495977761003292660913E+00 -0.1769357445865517297623E+00 -0.9757911121022322387120E+00 -0.1285513431664240813213E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2624                             0                             0                             0                             0                             0                             0
 -0.2878371028261965669515E+00  0.1454899278495849213044E+00  0.2342141099702369222424E+00 -0.1699654028269927119599E+00 -0.9757911121022320166674E+00 -0.1376352694048560143525E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2625                             0                             0                             0                             0                             0                             0
 -0.2752438591389835265133E+00  0.1454899278495849213044E+00  0.2194693160631140393946E+00 -0.1625291977124349585004E+00 -0.9757911121022321276897E+00 -0.1463419469367598091392E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2626                             0                             0                             0                             0                             0                             0
 -0.2618961911658370667055E+00  0.1454899278495849213044E+00  0.2054038088341630374778E+00 -0.1546475113642137022563E+00 -0.9757911121022323497343E+00 -0.1546475113642136467451E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2627                             0                             0                             0                             0                             0                             0
 -0.2478306839368857872330E+00  0.1454899278495849213044E+00  0.1920561408610163001143E+00 -0.1463419469367596981169E+00 -0.9757911121022322387120E+00 -0.1625291977124350417672E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2628                             0                             0                             0                             0                             0                             0
 -0.2330858900297634317411E+00  0.1454899278495849213044E+00  0.1794628971738037037653E+00 -0.1376352694048562086415E+00 -0.9757911121022322387120E+00 -0.1699654028269925454264E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2629                             0                             0                             0                             0                             0                             0
 -0.2177022238996707825809E+00  0.1454899278495849213044E+00  0.1676585949781257967039E+00 -0.1285513431664241368324E+00 -0.9757911121022321276897E+00 -0.1769357445865516742511E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2630                             0                             0                             0                             0                             0                             0
 -0.2017218511061655006333E+00  0.1454899278495849213044E+00  0.1566755890457943167782E+00 -0.1191150666318673695399E+00 -0.9757911121022322387120E+00 -0.1834211177688517546702E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2631                             0                             0                             0                             0                             0                             0
 -0.1851885727402915737816E+00  0.1454899278495849213044E+00  0.1465439830326498715785E+00 -0.1093523039792590745289E+00 -0.9757911121022321276897E+00 -0.1894037464167932227621E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2632                             0                             0                             0                             0                             0                             0
 -0.1681477053688369416307E+00  0.1454899278495849213044E+00  0.1372915469665359489149E+00 -0.9928981426242941554783E-01 -0.9757911121022321276897E+00 -0.1948672325610990574418E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2633                             0                             0                             0                             0                             0                             0
 -0.1506459568247697500265E+00  0.1454899278495849213044E+00  0.1289436411315801889188E+00 -0.8895517806625664880560E-01 -0.9757911121022321276897E+00 -0.1997966011660102514380E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2634                             0                             0                             0                             0                             0                             0
 -0.1327312981843182249087E+00  0.1454899278495849213044E+00  0.1215231465574208025160E+00 -0.7837672191020306211584E-01 -0.9757911121022322387120E+00 -0.2041783411748168131084E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2635                             0                             0                             0                             0                             0                             0
 -0.1144528322815825810421E+00  0.1454899278495849213044E+00  0.1150504023038930734302E+00 -0.6758344060729257196662E-01 -0.9757911121022321276897E+00 -0.2080004425427257330750E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2636                             0                             0                             0                             0                             0                             0
 -0.9586065912108196473973E-01  0.1454899278495849213044E+00  0.1095431497130809894713E+00 -0.5660491779134484147118E-01 -0.9757911121022321276897E+00 -0.2112524291555585576052E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2637                             0                             0                             0                             0                             0                             0
 -0.7700573855712318505073E-01  0.1454899278495849213044E+00  0.1050164837815316110081E+00 -0.4547124483029063579664E-01 -0.9757911121022321276897E+00 -0.2139253875440522700835E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2638                             0                             0                             0                             0                             0                             0
 -0.5793975061638289431043E-01  0.1454899278495849213044E+00  0.1014828117859186695782E+00 -0.3421293834782426768193E-01 -0.9757911121022320166674E+00 -0.2160119913150591042239E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2639                             0                             0                             0                             0                             0                             0
 -0.3871495384654546900727E-01  0.1454899278495849213044E+00  0.9895181927555940504249E-01 -0.2286085657945851126738E-01 -0.9757911121022322387120E+00 -0.2175065212326807995158E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2640                             0                             0                             0                             0                             0                             0
 -0.1938404207925843031335E-01  0.1454899278495849213044E+00  0.9743044352499785620836E-01 -0.1144611479224730450632E-01 -0.9757911121022320166674E+00 -0.2184048808942966046764E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2641                             0                             0                             0                             0                             0                             0
  0.2059584207234561445540E-16  0.1354477585648095894211E+00  0.1309443734359124200672E+00  0.2049810739450918309433E-16 -0.9423036020307958837705E+00 -0.3347594981472333808270E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2642                             0                             0                             0                             0                             0                             0
  0.1760349335392608766115E-01  0.1354477585648095894211E+00  0.1314053371322220220563E+00  0.1751995844694348783421E-01 -0.9423036020307957727482E+00 -0.3343007218894463172809E+00
