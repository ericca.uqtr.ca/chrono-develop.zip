                          2294                             0                             0                             0                             0                             0                             0
  0.2691510332954276663031E+00  0.1437667757714512495326E+00  0.1349261543050055411896E+00 -0.2884670052241679050198E+00 -0.8887570259422461482757E+00  0.3562270845055066637030E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2295                             0                             0                             0                             0                             0                             0
  0.2861772742031178928812E+00  0.1437667757714512495326E+00  0.1494679378103117572962E+00 -0.3067151563262876523552E+00 -0.8887570259422460372534E+00  0.3406416911037672967666E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2296                             0                             0                             0                             0                             0                             0
  0.3024191230941558616863E+00  0.1437667757714512495326E+00  0.1648808769058440759636E+00 -0.3241226225044261388675E+00 -0.8887570259422461482757E+00  0.3241226225044261943786E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2297                             0                             0                             0                             0                             0                             0
  0.3178320621896882913759E+00  0.1437667757714512495326E+00  0.1811227257968821002798E+00 -0.3406416911037673522777E+00 -0.8887570259422461482757E+00  0.3067151563262876523552E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2298                             0                             0                             0                             0                             0                             0
  0.3323738456949945074825E+00  0.1437667757714512495326E+00  0.1981489667045723823691E+00 -0.3562270845055067192142E+00 -0.8887570259422461482757E+00  0.2884670052241678495086E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2299                             0                             0                             0                             0                             0                             0
  0.3460046155922735233723E+00  0.1437667757714512495326E+00  0.2159129318860664725754E+00 -0.3708360842296575810018E+00 -0.8887570259422461482757E+00  0.2694281861118243415198E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2300                             0                             0                             0                             0                             0                             0
  0.3586870108887000307973E+00  0.1437667757714512495326E+00  0.2343659315475600246614E+00 -0.3844286480234350711349E+00 -0.8887570259422461482757E+00  0.2496508830690719049628E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2301                             0                             0                             0                             0                             0                             0
  0.3703862700203090496665E+00  0.1437667757714512495326E+00  0.2534573872996331300733E+00 -0.3969675196142880002625E+00 -0.8887570259422460372534E+00  0.2291893043088472359248E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2302                             0                             0                             0                             0                             0                             0
  0.3810703261310264267081E+00  0.1437667757714512495326E+00  0.2731349707891002065452E+00 -0.4084183308267522183321E+00 -0.8887570259422462592980E+00  0.2080995335962652348361E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2303                             0                             0                             0                             0                             0                             0
  0.3907098949656921949014E+00  0.1437667757714512495326E+00  0.2933447471273885609477E+00 -0.4187496957832303468017E+00 -0.8887570259422461482757E+00  0.1864393765269171665544E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2304                             0                             0                             0                             0                             0                             0
  0.3992785551361688334282E+00  0.1437667757714512495326E+00  0.3140313227223194836313E+00 -0.4279332969305011391548E+00 -0.8887570259422461482757E+00  0.1642682020857509084255E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2305                             0                             0                             0                             0                             0                             0
  0.4067528205405293029173E+00  0.1437667757714512495326E+00  0.3351379971080933328764E+00 -0.4359439626561641412117E+00 -0.8887570259422460372534E+00  0.1416467799208103173214E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2306                             0                             0                             0                             0                             0                             0
  0.4131122047368301353210E+00  0.1437667757714512495326E+00  0.3566069183573257750375E+00 -0.4427597362822799920146E+00 -0.8887570259422461482757E+00  0.1186371137778537421248E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2307                             0                             0                             0                             0                             0                             0
  0.4183392770950246086770E+00  0.1437667757714512495326E+00  0.3783792416491589816196E+00 -0.4483619362470979696766E+00 -0.8887570259422462592980E+00  0.9530227155239673342280E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2308                             0                             0                             0                             0                             0                             0
  0.4224197105731081758329E+00  0.1437667757714512495326E+00  0.4003952905588256672154E+00 -0.4527352073099187856897E+00 -0.8887570259422461482757E+00  0.7170621242499439218498E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2309                             0                             0                             0                             0                             0                             0
  0.4253423209865448972877E+00  0.1437667757714512495326E+00  0.4225947206265813216319E+00 -0.4558675626387414525631E+00 -0.8887570259422461482757E+00  0.4791361155357274498323E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2310                             0                             0                             0                             0                             0                             0
  0.4270990976633397551154E+00  0.1437667757714512495326E+00  0.4449166847576737082726E+00 -0.4577504166653371120432E+00 -0.8887570259422460372534E+00  0.2398968280331706393049E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2311                             0                             0                             0                             0                             0                             0
  0.4276852254007337261754E+00  0.1437667757714512495326E+00  0.4672999999999998821387E+00 -0.4583786086176944718495E+00 -0.8887570259422461482757E+00  0.1017804970566015203225E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2312                             0                             0                             0                             0                             0                             0
  0.4270990976633397551154E+00  0.1437667757714512495326E+00  0.4896833152423262780495E+00 -0.4577504166653371120432E+00 -0.8887570259422460372534E+00 -0.2398968280331706393049E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2313                             0                             0                             0                             0                             0                             0
  0.4253423209865448972877E+00  0.1437667757714512495326E+00  0.5120052793734186646901E+00 -0.4558675626387414525631E+00 -0.8887570259422461482757E+00 -0.4791361155357274498323E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2314                             0                             0                             0                             0                             0                             0
  0.4224197105731081758329E+00  0.1437667757714512495326E+00  0.5342047094411743746178E+00 -0.4527352073099187856897E+00 -0.8887570259422461482757E+00 -0.7170621242499439218498E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2315                             0                             0                             0                             0                             0                             0
  0.4183392770950245531658E+00  0.1437667757714512495326E+00  0.5562207583508410602136E+00 -0.4483619362470979696766E+00 -0.8887570259422461482757E+00 -0.9530227155239683056731E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2316                             0                             0                             0                             0                             0                             0
  0.4131122047368301353210E+00  0.1437667757714512495326E+00  0.5779930816426742667957E+00 -0.4427597362822799920146E+00 -0.8887570259422461482757E+00 -0.1186371137778537421248E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2317                             0                             0                             0                             0                             0                             0
  0.4067528205405293029173E+00  0.1437667757714512495326E+00  0.5994620028919066534456E+00 -0.4359439626561641412117E+00 -0.8887570259422460372534E+00 -0.1416467799208103173214E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2318                             0                             0                             0                             0                             0                             0
  0.3992785551361688334282E+00  0.1437667757714512495326E+00  0.6205686772776805026908E+00 -0.4279332969305011391548E+00 -0.8887570259422461482757E+00 -0.1642682020857509084255E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2319                             0                             0                             0                             0                             0                             0
  0.3907098949656922504126E+00  0.1437667757714512495326E+00  0.6412552528726114253743E+00 -0.4187496957832304023128E+00 -0.8887570259422462592980E+00 -0.1864393765269170832877E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2320                             0                             0                             0                             0                             0                             0
  0.3810703261310264267081E+00  0.1437667757714512495326E+00  0.6614650292108997797769E+00 -0.4084183308267522183321E+00 -0.8887570259422462592980E+00 -0.2080995335962652348361E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2321                             0                             0                             0                             0                             0                             0
  0.3703862700203091051776E+00  0.1437667757714512495326E+00  0.6811426127003668007376E+00 -0.3969675196142880557737E+00 -0.8887570259422461482757E+00 -0.2291893043088471526580E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2322                             0                             0                             0                             0                             0                             0
  0.3586870108887000863085E+00  0.1437667757714512495326E+00  0.7002340684524398506383E+00 -0.3844286480234351266461E+00 -0.8887570259422461482757E+00 -0.2496508830690717939405E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2323                             0                             0                             0                             0                             0                             0
  0.3460046155922735233723E+00  0.1437667757714512495326E+00  0.7186870681139334582355E+00 -0.3708360842296575810018E+00 -0.8887570259422461482757E+00 -0.2694281861118243415198E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2324                             0                             0                             0                             0                             0                             0
  0.3323738456949945629937E+00  0.1437667757714512495326E+00  0.7364510332954274929307E+00 -0.3562270845055067747253E+00 -0.8887570259422461482757E+00 -0.2884670052241677939975E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2325                             0                             0                             0                             0                             0                             0
  0.3178320621896884023982E+00  0.1437667757714512495326E+00  0.7534772742031178305311E+00 -0.3406416911037674633000E+00 -0.8887570259422461482757E+00 -0.3067151563262875413329E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2326                             0                             0                             0                             0                             0                             0
  0.3024191230941559171974E+00  0.1437667757714512495326E+00  0.7697191230941557993361E+00 -0.3241226225044261943786E+00 -0.8887570259422461482757E+00 -0.3241226225044261388675E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2327                             0                             0                             0                             0                             0                             0
  0.2861772742031179483924E+00  0.1437667757714512495326E+00  0.7851320621896882290258E+00 -0.3067151563262877078664E+00 -0.8887570259422461482757E+00 -0.3406416911037672967666E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2328                             0                             0                             0                             0                             0                             0
  0.2691510332954276107920E+00  0.1437667757714512495326E+00  0.7996738456949945561547E+00 -0.2884670052241678495086E+00 -0.8887570259422461482757E+00 -0.3562270845055067192142E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2329                             0                             0                             0                             0                             0                             0
  0.2513870681139335205856E+00  0.1437667757714512495326E+00  0.8133046155922735165333E+00 -0.2694281861118243415198E+00 -0.8887570259422461482757E+00 -0.3708360842296575810018E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2330                             0                             0                             0                             0                             0                             0
  0.2329340684524400240107E+00  0.1437667757714512495326E+00  0.8259870108886999684472E+00 -0.2496508830690719327183E+00 -0.8887570259422461482757E+00 -0.3844286480234350156238E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2331                             0                             0                             0                             0                             0                             0
  0.2138426127003668075766E+00  0.1437667757714512495326E+00  0.8376862700203091538498E+00 -0.2291893043088471804136E+00 -0.8887570259422461482757E+00 -0.3969675196142880557737E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2332                             0                             0                             0                             0                             0                             0
  0.1941650292108998143714E+00  0.1437667757714512495326E+00  0.8483703261310263643580E+00 -0.2080995335962652625916E+00 -0.8887570259422460372534E+00 -0.4084183308267521628210E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2333                             0                             0                             0                             0                             0                             0
  0.1739552528726112934354E+00  0.1437667757714512495326E+00  0.8580098949656922435736E+00 -0.1864393765269170000209E+00 -0.8887570259422461482757E+00 -0.4187496957832304023128E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2334                             0                             0                             0                             0                             0                             0
  0.1532686772776804817742E+00  0.1437667757714512495326E+00  0.8665785551361688821004E+00 -0.1642682020857508251588E+00 -0.8887570259422461482757E+00 -0.4279332969305011391548E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2335                             0                             0                             0                             0                             0                             0
  0.1321620028919066602846E+00  0.1437667757714512495326E+00  0.8740528205405293515895E+00 -0.1416467799208103450770E+00 -0.8887570259422460372534E+00 -0.4359439626561641412117E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2336                             0                             0                             0                             0                             0                             0
  0.1106930816426741626124E+00  0.1437667757714512495326E+00  0.8804122047368301284820E+00 -0.1186371137778536588581E+00 -0.8887570259422460372534E+00 -0.4427597362822799920146E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2337                             0                             0                             0                             0                             0                             0
  0.8892075835084101154138E-01  0.1437667757714512495326E+00  0.8856392770950245463268E+00 -0.9530227155239676117837E-01 -0.8887570259422462592980E+00 -0.4483619362470979696766E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2338                             0                             0                             0                             0                             0                             0
  0.6690470944117436757903E-01  0.1437667757714512495326E+00  0.8897197105731081689939E+00 -0.7170621242499441994056E-01 -0.8887570259422461482757E+00 -0.4527352073099187856897E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2339                             0                             0                             0                             0                             0                             0
  0.4470527937341858826237E-01  0.1437667757714512495326E+00  0.8926423209865449459599E+00 -0.4791361155357267559429E-01 -0.8887570259422461482757E+00 -0.4558675626387415080742E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2340                             0                             0                             0                             0                             0                             0
  0.2238331524232633346072E-01  0.1437667757714512495326E+00  0.8943990976633398037876E+00 -0.2398968280331709515552E-01 -0.8887570259422460372534E+00 -0.4577504166653371120432E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2341                             0                             0                             0                             0                             0                             0
  0.2161185609292389126679E-15  0.1437667757714512495326E+00  0.8949852254007337748476E+00 -0.2316285889052668935625E-15 -0.8887570259422461482757E+00 -0.4583786086176944718495E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2342                             0                             0                             0                             0                             0                             0
 -0.2238331524232627794957E-01  0.1437667757714512495326E+00  0.8943990976633398037876E+00  0.2398968280331703617492E-01 -0.8887570259422460372534E+00 -0.4577504166653371120432E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2343                             0                             0                             0                             0                             0                             0
 -0.4470527937341853275122E-01  0.1437667757714512495326E+00  0.8926423209865449459599E+00  0.4791361155357262008314E-01 -0.8887570259422461482757E+00 -0.4558675626387415080742E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2344                             0                             0                             0                             0                             0                             0
 -0.6690470944117431206788E-01  0.1437667757714512495326E+00  0.8897197105731081689939E+00  0.7170621242499436442941E-01 -0.8887570259422461482757E+00 -0.4527352073099187856897E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2345                             0                             0                             0                             0                             0                             0
 -0.8892075835084096990801E-01  0.1437667757714512495326E+00  0.8856392770950245463268E+00  0.9530227155239670566722E-01 -0.8887570259422462592980E+00 -0.4483619362470979696766E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2346                             0                             0                             0                             0                             0                             0
 -0.1106930816426741071012E+00  0.1437667757714512495326E+00  0.8804122047368301284820E+00  0.1186371137778536172247E+00 -0.8887570259422462592980E+00 -0.4427597362822800475257E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2347                             0                             0                             0                             0                             0                             0
 -0.1321620028919066325290E+00  0.1437667757714512495326E+00  0.8740528205405293515895E+00  0.1416467799208102895658E+00 -0.8887570259422461482757E+00 -0.4359439626561641967228E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2348                             0                             0                             0                             0                             0                             0
 -0.1532686772776804262630E+00  0.1437667757714512495326E+00  0.8665785551361688821004E+00  0.1642682020857507696476E+00 -0.8887570259422461482757E+00 -0.4279332969305011946659E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2349                             0                             0                             0                             0                             0                             0
 -0.1739552528726114322133E+00  0.1437667757714512495326E+00  0.8580098949656922435736E+00  0.1864393765269171387988E+00 -0.8887570259422461482757E+00 -0.4187496957832303468017E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2350                             0                             0                             0                             0                             0                             0
 -0.1941650292108997866158E+00  0.1437667757714512495326E+00  0.8483703261310264753803E+00  0.2080995335962652070805E+00 -0.8887570259422461482757E+00 -0.4084183308267522183321E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2351                             0                             0                             0                             0                             0                             0
 -0.2138426127003667798210E+00  0.1437667757714512495326E+00  0.8376862700203091538498E+00  0.2291893043088471249025E+00 -0.8887570259422460372534E+00 -0.3969675196142880557737E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2352                             0                             0                             0                             0                             0                             0
 -0.2329340684524399684996E+00  0.1437667757714512495326E+00  0.8259870108886999684472E+00  0.2496508830690719049628E+00 -0.8887570259422459262311E+00 -0.3844286480234350156238E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2353                             0                             0                             0                             0                             0                             0
 -0.2513870681139334650744E+00  0.1437667757714512495326E+00  0.8133046155922735165333E+00  0.2694281861118242860087E+00 -0.8887570259422460372534E+00 -0.3708360842296575810018E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2354                             0                             0                             0                             0                             0                             0
 -0.2691510332954275552808E+00  0.1437667757714512495326E+00  0.7996738456949945561547E+00  0.2884670052241677939975E+00 -0.8887570259422461482757E+00 -0.3562270845055067747253E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2355                             0                             0                             0                             0                             0                             0
 -0.2861772742031178928812E+00  0.1437667757714512495326E+00  0.7851320621896882290258E+00  0.3067151563262876523552E+00 -0.8887570259422461482757E+00 -0.3406416911037673522777E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2356                             0                             0                             0                             0                             0                             0
 -0.3024191230941558616863E+00  0.1437667757714512495326E+00  0.7697191230941559103584E+00  0.3241226225044261388675E+00 -0.8887570259422461482757E+00 -0.3241226225044261943786E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2357                             0                             0                             0                             0                             0                             0
 -0.3178320621896881803536E+00  0.1437667757714512495326E+00  0.7534772742031179415534E+00  0.3406416911037672412554E+00 -0.8887570259422460372534E+00 -0.3067151563262877078664E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2358                             0                             0                             0                             0                             0                             0
 -0.3323738456949944519714E+00  0.1437667757714512495326E+00  0.7364510332954277149753E+00  0.3562270845055066637030E+00 -0.8887570259422461482757E+00 -0.2884670052241680160421E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2359                             0                             0                             0                             0                             0                             0
 -0.3460046155922734678612E+00  0.1437667757714512495326E+00  0.7186870681139335692578E+00  0.3708360842296575254906E+00 -0.8887570259422461482757E+00 -0.2694281861118243970310E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2360                             0                             0                             0                             0                             0                             0
 -0.3586870108887000863085E+00  0.1437667757714512495326E+00  0.7002340684524399616606E+00  0.3844286480234351266461E+00 -0.8887570259422461482757E+00 -0.2496508830690718494516E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2361                             0                             0                             0                             0                             0                             0
 -0.3703862700203089941553E+00  0.1437667757714512495326E+00  0.6811426127003670227822E+00  0.3969675196142879447514E+00 -0.8887570259422461482757E+00 -0.2291893043088474024582E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2362                             0                             0                             0                             0                             0                             0
 -0.3810703261310263711970E+00  0.1437667757714512495326E+00  0.6614650292108998907992E+00  0.4084183308267521628210E+00 -0.8887570259422461482757E+00 -0.2080995335962652625916E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2363                             0                             0                             0                             0                             0                             0
 -0.3907098949656920838791E+00  0.1437667757714512495326E+00  0.6412552528726116474189E+00  0.4187496957832302357794E+00 -0.8887570259422461482757E+00 -0.1864393765269173885990E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2364                             0                             0                             0                             0                             0                             0
 -0.3992785551361689444505E+00  0.1437667757714512495326E+00  0.6205686772776802806462E+00  0.4279332969305011946659E+00 -0.8887570259422461482757E+00 -0.1642682020857506586253E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2365                             0                             0                             0                             0                             0                             0
 -0.4067528205405293029173E+00  0.1437667757714512495326E+00  0.5994620028919066534456E+00  0.4359439626561641412117E+00 -0.8887570259422460372534E+00 -0.1416467799208103450770E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2366                             0                             0                             0                             0                             0                             0
 -0.4131122047368301353210E+00  0.1437667757714512495326E+00  0.5779930816426741557734E+00  0.4427597362822799920146E+00 -0.8887570259422460372534E+00 -0.1186371137778536866136E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2367                             0                             0                             0                             0                             0                             0
 -0.4183392770950245531658E+00  0.1437667757714512495326E+00  0.5562207583508411712359E+00  0.4483619362470979696766E+00 -0.8887570259422462592980E+00 -0.9530227155239698322298E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2368                             0                             0                             0                             0                             0                             0
 -0.4224197105731081203217E+00  0.1437667757714512495326E+00  0.5342047094411743746178E+00  0.4527352073099187301786E+00 -0.8887570259422461482757E+00 -0.7170621242499444769614E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2369                             0                             0                             0                             0                             0                             0
 -0.4253423209865448972877E+00  0.1437667757714512495326E+00  0.5120052793734189977570E+00  0.4558675626387414525631E+00 -0.8887570259422462592980E+00 -0.4791361155357310580571E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2370                             0                             0                             0                             0                             0                             0
 -0.4270990976633398106266E+00  0.1437667757714512495326E+00  0.4896833152423261670272E+00  0.4577504166653371675544E+00 -0.8887570259422462592980E+00 -0.2398968280331691821372E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2371                             0                             0                             0                             0                             0                             0
 -0.4276852254007337261754E+00  0.1437667757714512495326E+00  0.4673000000000000486722E+00  0.4583786086176944718495E+00 -0.8887570259422461482757E+00 -0.5613518958412769350901E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2372                             0                             0                             0                             0                             0                             0
 -0.4270990976633397551154E+00  0.1437667757714512495326E+00  0.4449166847576735417391E+00  0.4577504166653371120432E+00 -0.8887570259422461482757E+00  0.2398968280331721311671E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2373                             0                             0                             0                             0                             0                             0
 -0.4253423209865449527989E+00  0.1437667757714512495326E+00  0.4225947206265814881654E+00  0.4558675626387415080742E+00 -0.8887570259422461482757E+00  0.4791361155357259232757E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2374                             0                             0                             0                             0                             0                             0
 -0.4224197105731081758329E+00  0.1437667757714512495326E+00  0.4003952905588257227265E+00  0.4527352073099187856897E+00 -0.8887570259422461482757E+00  0.7170621242499433667383E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2375                             0                             0                             0                             0                             0                             0
 -0.4183392770950245531658E+00  0.1437667757714512495326E+00  0.3783792416491588705973E+00  0.4483619362470979696766E+00 -0.8887570259422461482757E+00  0.9530227155239688607846E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2376                             0                             0                             0                             0                             0                             0
 -0.4131122047368300798098E+00  0.1437667757714512495326E+00  0.3566069183573255529929E+00  0.4427597362822799365034E+00 -0.8887570259422461482757E+00  0.1186371137778539641694E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2377                             0                             0                             0                             0                             0                             0
 -0.4067528205405293584285E+00  0.1437667757714512495326E+00  0.3351379971080933883876E+00  0.4359439626561641967228E+00 -0.8887570259422461482757E+00  0.1416467799208102618103E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2378                             0                             0                             0                             0                             0                             0
 -0.3992785551361689444505E+00  0.1437667757714512495326E+00  0.3140313227223197611870E+00  0.4279332969305011946659E+00 -0.8887570259422460372534E+00  0.1642682020857505753586E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2379                             0                             0                             0                             0                             0                             0
 -0.3907098949656923059237E+00  0.1437667757714512495326E+00  0.2933447471273887829923E+00  0.4187496957832304023128E+00 -0.8887570259422461482757E+00  0.1864393765269169445098E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2380                             0                             0                             0                             0                             0                             0
 -0.3810703261310264267081E+00  0.1437667757714512495326E+00  0.2731349707891002065452E+00  0.4084183308267522183321E+00 -0.8887570259422461482757E+00  0.2080995335962652070805E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2381                             0                             0                             0                             0                             0                             0
 -0.3703862700203090496665E+00  0.1437667757714512495326E+00  0.2534573872996330745622E+00  0.3969675196142880002625E+00 -0.8887570259422461482757E+00  0.2291893043088472914359E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2382                             0                             0                             0                             0                             0                             0
 -0.3586870108887001418196E+00  0.1437667757714512495326E+00  0.2343659315475601634393E+00  0.3844286480234351821572E+00 -0.8887570259422461482757E+00  0.2496508830690717384293E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2383                             0                             0                             0                             0                             0                             0
 -0.3460046155922735788835E+00  0.1437667757714512495326E+00  0.2159129318860665280866E+00  0.3708360842296576365129E+00 -0.8887570259422462592980E+00  0.2694281861118242860087E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2384                             0                             0                             0                             0                             0                             0
 -0.3323738456949947295271E+00  0.1437667757714512495326E+00  0.1981489667045726599248E+00  0.3562270845055069412588E+00 -0.8887570259422459262311E+00  0.2884670052241675719529E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2385                             0                             0                             0                             0                             0                             0
 -0.3178320621896881248425E+00  0.1437667757714512495326E+00  0.1811227257968819337464E+00  0.3406416911037671857443E+00 -0.8887570259422461482757E+00  0.3067151563262878188887E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2386                             0                             0                             0                             0                             0                             0
 -0.3024191230941559727086E+00  0.1437667757714512495326E+00  0.1648808769058441314748E+00  0.3241226225044262498898E+00 -0.8887570259422463703203E+00  0.3241226225044261388675E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2387                             0                             0                             0                             0                             0                             0
 -0.2861772742031178928812E+00  0.1437667757714512495326E+00  0.1494679378103116462739E+00  0.3067151563262875968441E+00 -0.8887570259422462592980E+00  0.3406416911037674077889E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2388                             0                             0                             0                             0                             0                             0
 -0.2691510332954277773254E+00  0.1437667757714512495326E+00  0.1349261543050055967008E+00  0.2884670052241680715532E+00 -0.8887570259422461482757E+00  0.3562270845055066081919E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2389                             0                             0                             0                             0                             0                             0
 -0.2513870681139335760967E+00  0.1437667757714512495326E+00  0.1212953844077265252999E+00  0.2694281861118243970310E+00 -0.8887570259422461482757E+00  0.3708360842296575254906E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2390                             0                             0                             0                             0                             0                             0
 -0.2329340684524402460553E+00  0.1437667757714512495326E+00  0.1086129891113001288971E+00  0.2496508830690722102741E+00 -0.8887570259422461482757E+00  0.3844286480234348490903E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2391                             0                             0                             0                             0                             0                             0
 -0.2138426127003666965543E+00  0.1437667757714512495326E+00  0.9691372997969083247227E-01  0.2291893043088470693913E+00 -0.8887570259422460372534E+00  0.3969675196142881112848E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2392                             0                             0                             0                             0                             0                             0
 -0.1941650292108998698826E+00  0.1437667757714512495326E+00  0.8622967386897362196407E-01  0.2080995335962652903472E+00 -0.8887570259422461482757E+00  0.4084183308267521628210E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2393                             0                             0                             0                             0                             0                             0
 -0.1739552528726113489466E+00  0.1437667757714512495326E+00  0.7659010503430774274847E-01  0.1864393765269170555321E+00 -0.8887570259422461482757E+00  0.4187496957832304023128E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2394                             0                             0                             0                             0                             0                             0
 -0.1532686772776807038188E+00  0.1437667757714512495326E+00  0.6802144486383121524398E-01  0.1642682020857510749590E+00 -0.8887570259422462592980E+00  0.4279332969305010836436E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2395                             0                             0                             0                             0                             0                             0
 -0.1321620028919067157958E+00  0.1437667757714512495326E+00  0.6054717945947069024371E-01  0.1416467799208103728326E+00 -0.8887570259422461482757E+00  0.4359439626561641412117E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2396                             0                             0                             0                             0                             0                             0
 -0.1106930816426742042458E+00  0.1437667757714512495326E+00  0.5418779526316985784007E-01  0.1186371137778537143692E+00 -0.8887570259422461482757E+00  0.4427597362822799920146E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2397                             0                             0                             0                             0                             0                             0
 -0.8892075835084088664129E-01  0.1437667757714512495326E+00  0.4896072290497538448406E-01  0.9530227155239662240049E-01 -0.8887570259422461482757E+00  0.4483619362470979696766E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2398                             0                             0                             0                             0                             0                             0
 -0.6690470944117440921239E-01  0.1437667757714512495326E+00  0.4488028942689187283932E-01  0.7170621242499447545171E-01 -0.8887570259422461482757E+00  0.4527352073099187301786E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2399                             0                             0                             0                             0                             0                             0
 -0.4470527937341864377352E-01  0.1437667757714512495326E+00  0.4195767901345504036215E-01  0.4791361155357273110544E-01 -0.8887570259422462592980E+00  0.4558675626387415080742E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2400                             0                             0                             0                             0                             0                             0
 -0.2238331524232657285256E-01  0.1437667757714512495326E+00  0.4020090233666023804560E-01  0.2398968280331735189459E-01 -0.8887570259422461482757E+00  0.4577504166653371120432E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2401                             0                             0                             0                             0                             0                             0
  0.2478447035001324042138E-16  0.1500082858941103047812E+00  0.6253888247175992676219E-01  0.1492889648218710989923E-17 -0.9997027456229882202976E+00 -0.2438073817296740330995E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2402                             0                             0                             0                             0                             0                             0
  0.2118356013580307076194E-01  0.1500082858941103047812E+00  0.6309359351603222032523E-01  0.1275989246191095664168E-02 -0.9997027456229882202976E+00 -0.2434732521864351600938E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2403                             0                             0                             0                             0                             0                             0
  0.4230905760572500895478E-01  0.1500082858941103047812E+00  0.6475620622443423179959E-01  0.2548481094551299525747E-02 -0.9997027456229881092753E+00 -0.2424717793825715422829E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2404                             0                             0                             0                             0                             0                             0
  0.6331858888961626463665E-01  0.1500082858941103047812E+00  0.6752216349109901871728E-01  0.3813987733374092810312E-02 -0.9997027456229883313199E+00 -0.2408057082854270572470E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2405                             0                             0                             0                             0                             0                             0
  0.8415456832258225161603E-01  0.1500082858941103047812E+00  0.7138388401941808680817E-01  0.5069040496926744028550E-02 -0.9997027456229881092753E+00 -0.2384796054800717227118E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2406                             0                             0                             0                             0                             0                             0
  0.1047598859332882631490E+00  0.1500082858941103047812E+00  0.7633078310184804315952E-01  0.6310199372821999677652E-02 -0.9997027456229882202976E+00 -0.2354998466526096734253E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2407                             0                             0                             0                             0                             0                             0
  0.1250780639784216108357E+00  0.1500082858941103047812E+00  0.8234930163185877338705E-01  0.7534062430852934283410E-02 -0.9997027456229882202976E+00 -0.2318745991148664364889E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2408                             0                             0                             0                             0                             0                             0
  0.1450534117442597303871E+00  0.1500082858941103047812E+00  0.8942294326850164232212E-01  0.8737275147447161327552E-02 -0.9997027456229883313199E+00 -0.2276137994183551407912E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2409                             0                             0                             0                             0                             0                             0
  0.1646311781910458071909E+00  0.1500082858941103047812E+00  0.9753231965173336792674E-01  0.9916539600182780467286E-02 -0.9997027456229881092753E+00 -0.2227291261188793503045E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2410                             0                             0                             0                             0                             0                             0
  0.1837577020217831536009E+00  0.1500082858941103047812E+00  0.1066552035445633705990E+00  0.1106862350716451663668E-01 -0.9997027456229881092753E+00 -0.2172339677664234317001E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2411                             0                             0                             0                             0                             0                             0
  0.2023805587641199776883E+00  0.1500082858941103047812E+00  0.1167665897563652244173E+00  0.1219036908648369818553E-01 -0.9997027456229883313199E+00 -0.2111433862080677389961E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2412                             0                             0                             0                             0                             0                             0
  0.2204487044621846469905E+00  0.1500082858941103047812E+00  0.1278387636803663407470E+00  0.1327870171147900110742E-01 -0.9997027456229883313199E+00 -0.2044740753045125314369E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2413                             0                             0                             0                             0                             0                             0
  0.2379126155845199541705E+00  0.1500082858941103047812E+00  0.1398413772574583768815E+00  0.1433063833807437549572E-01 -0.9997027456229883313199E+00 -0.1972443151733663593839E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2414                             0                             0                             0                             0                             0                             0
  0.2547244247646412995678E+00  0.1500082858941103047812E+00  0.1527415321581179208366E+00  0.1534329568109554613187E-01 -0.9997027456229881092753E+00 -0.1894739220846142213617E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2415                             0                             0                             0                             0                             0                             0
  0.2708380520021603787839E+00  0.1500082858941103047812E+00  0.1665038699544409972475E+00  0.1631389811715424145722E-01 -0.9997027456229881092753E+00 -0.1811841941455990048770E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2416                             0                             0                             0                             0                             0                             0
  0.2862093309648636729747E+00  0.1500082858941103047812E+00  0.1810906690351362646751E+00  0.1723978529243896593015E-01 -0.9997027456229883313199E+00 -0.1723978529243896939960E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2417                             0                             0                             0                             0                             0                             0
  0.3007961300455590514247E+00  0.1500082858941103047812E+00  0.1964619479978396143771E+00  0.1811841941455990395715E-01 -0.9997027456229883313199E+00 -0.1631389811715424145722E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2418                             0                             0                             0                             0                             0                             0
  0.3145584678418821278356E+00  0.1500082858941103047812E+00  0.2125755752353587491044E+00  0.1894739220846142560561E-01 -0.9997027456229882202976E+00 -0.1534329568109554439714E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2419                             0                             0                             0                             0                             0                             0
  0.3274586227425416162795E+00  0.1500082858941103047812E+00  0.2293873844154800389905E+00  0.1972443151733663593839E-01 -0.9997027456229883313199E+00 -0.1433063833807437549572E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2420                             0                             0                             0                             0                             0                             0
  0.3394612363196336524140E+00  0.1500082858941103047812E+00  0.2468512955378153461705E+00  0.2044740753045125314369E-01 -0.9997027456229883313199E+00 -0.1327870171147900110742E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2421                             0                             0                             0                             0                             0                             0
  0.3505334102436347132326E+00  0.1500082858941103047812E+00  0.2649194412358799599616E+00  0.2111433862080677043016E-01 -0.9997027456229882202976E+00 -0.1219036908648370165498E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2422                             0                             0                             0                             0                             0                             0
  0.3606447964554366780732E+00  0.1500082858941103047812E+00  0.2835422979782168395602E+00  0.2172339677664234663945E-01 -0.9997027456229882202976E+00 -0.1106862350716451490196E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2423                             0                             0                             0                             0                             0                             0
  0.3697676803482666252343E+00  0.1500082858941103047812E+00  0.3026688218089541582145E+00  0.2227291261188793503045E-01 -0.9997027456229882202976E+00 -0.9916539600182782202009E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2424                             0                             0                             0                             0                             0                             0
  0.3778770567314983508389E+00  0.1500082858941103047812E+00  0.3222465882557402627739E+00  0.2276137994183551407912E-01 -0.9997027456229882202976E+00 -0.8737275147447159592828E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2425                             0                             0                             0                             0                             0                             0
  0.3849506983681412197740E+00  0.1500082858941103047812E+00  0.3422219360215784100809E+00  0.2318745991148664364889E-01 -0.9997027456229882202976E+00 -0.7534062430852933416048E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2426                             0                             0                             0                             0                             0                             0
  0.3909692168981519500015E+00  0.1500082858941103047812E+00  0.3625401140667117716454E+00  0.2354998466526096734253E-01 -0.9997027456229882202976E+00 -0.6310199372821997942928E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2427                             0                             0                             0                             0                             0                             0
  0.3959161159805819618640E+00  0.1500082858941103047812E+00  0.3831454316774178803229E+00  0.2384796054800717574063E-01 -0.9997027456229882202976E+00 -0.5069040496926737089656E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2428                             0                             0                             0                             0                             0                             0
  0.3997778365089009744437E+00  0.1500082858941103047812E+00  0.4039814111103837701577E+00  0.2408057082854270572470E-01 -0.9997027456229883313199E+00 -0.3813987733374091509270E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2429                             0                             0                             0                             0                             0                             0
  0.4025437937755657613614E+00  0.1500082858941103047812E+00  0.4249909423942750397174E+00  0.2424717793825715422829E-01 -0.9997027456229879982530E+00 -0.2548481094551297791023E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2430                             0                             0                             0                             0                             0                             0
  0.4042064064839677728358E+00  0.1500082858941103047812E+00  0.4461164398641970230130E+00  0.2434732521864351600938E-01 -0.9997027456229882202976E+00 -0.1275989246191088725274E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2431                             0                             0                             0                             0                             0                             0
  0.4047611175282400663988E+00  0.1500082858941103047812E+00  0.4672999999999998821387E+00  0.2438073817296740330995E-01 -0.9997027456229882202976E+00 -0.5413611375397176697078E-17
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2432                             0                             0                             0                             0                             0                             0
  0.4042064064839677728358E+00  0.1500082858941103047812E+00  0.4884835601358029633090E+00  0.2434732521864351600938E-01 -0.9997027456229882202976E+00  0.1275989246191088725274E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2433                             0                             0                             0                             0                             0                             0
  0.4025437937755657613614E+00  0.1500082858941103047812E+00  0.5096090576057249466047E+00  0.2424717793825715422829E-01 -0.9997027456229879982530E+00  0.2548481094551297791023E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2434                             0                             0                             0                             0                             0                             0
  0.3997778365089009744437E+00  0.1500082858941103047812E+00  0.5306185888896162161643E+00  0.2408057082854270572470E-01 -0.9997027456229883313199E+00  0.3813987733374091509270E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2435                             0                             0                             0                             0                             0                             0
  0.3959161159805819063529E+00  0.1500082858941103047812E+00  0.5514545683225822170215E+00  0.2384796054800717227118E-01 -0.9997027456229879982530E+00  0.5069040496926743161188E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2436                             0                             0                             0                             0                             0                             0
  0.3909692168981519500015E+00  0.1500082858941103047812E+00  0.5720598859332882701878E+00  0.2354998466526096734253E-01 -0.9997027456229882202976E+00  0.6310199372821997942928E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2437                             0                             0                             0                             0                             0                             0
  0.3849506983681412197740E+00  0.1500082858941103047812E+00  0.5923780639784215207300E+00  0.2318745991148664364889E-01 -0.9997027456229882202976E+00  0.7534062430852933416048E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2438                             0                             0                             0                             0                             0                             0
  0.3778770567314983508389E+00  0.1500082858941103047812E+00  0.6123534117442597235481E+00  0.2276137994183551407912E-01 -0.9997027456229882202976E+00  0.8737275147447159592828E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2439                             0                             0                             0                             0                             0                             0
  0.3697676803482666807454E+00  0.1500082858941103047812E+00  0.6319311781910457170852E+00  0.2227291261188793849990E-01 -0.9997027456229882202976E+00  0.9916539600182778732562E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2440                             0                             0                             0                             0                             0                             0
  0.3606447964554366780732E+00  0.1500082858941103047812E+00  0.6510577020217831467619E+00  0.2172339677664234663945E-01 -0.9997027456229882202976E+00  0.1106862350716451490196E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2441                             0                             0                             0                             0                             0                             0
  0.3505334102436347687437E+00  0.1500082858941103047812E+00  0.6696805587641199153381E+00  0.2111433862080677389961E-01 -0.9997027456229882202976E+00  0.1219036908648369818553E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2442                             0                             0                             0                             0                             0                             0
  0.3394612363196336524140E+00  0.1500082858941103047812E+00  0.6877487044621845013737E+00  0.2044740753045125661314E-01 -0.9997027456229883313199E+00  0.1327870171147899590325E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2443                             0                             0                             0                             0                             0                             0
  0.3274586227425416162795E+00  0.1500082858941103047812E+00  0.7052126155845199750871E+00  0.1972443151733663593839E-01 -0.9997027456229883313199E+00  0.1433063833807437549572E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2444                             0                             0                             0                             0                             0                             0
  0.3145584678418821833468E+00  0.1500082858941103047812E+00  0.7220244247646412372177E+00  0.1894739220846142907506E-01 -0.9997027456229881092753E+00  0.1534329568109554092770E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2445                             0                             0                             0                             0                             0                             0
  0.3007961300455591069358E+00  0.1500082858941103047812E+00  0.7381380520021603164338E+00  0.1811841941455991089605E-01 -0.9997027456229883313199E+00  0.1631389811715423451832E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2446                             0                             0                             0                             0                             0                             0
  0.2862093309648637284859E+00  0.1500082858941103047812E+00  0.7535093309648637216469E+00  0.1723978529243896939960E-01 -0.9997027456229883313199E+00  0.1723978529243896593015E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2447                             0                             0                             0                             0                             0                             0
  0.2708380520021603787839E+00  0.1500082858941103047812E+00  0.7680961300455589890746E+00  0.1631389811715424145722E-01 -0.9997027456229881092753E+00  0.1811841941455990048770E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2448                             0                             0                             0                             0                             0                             0
  0.2547244247646412440567E+00  0.1500082858941103047812E+00  0.7818584678418820654855E+00  0.1534329568109554439714E-01 -0.9997027456229882202976E+00  0.1894739220846142560561E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2449                             0                             0                             0                             0                             0                             0
  0.2379126155845199541705E+00  0.1500082858941103047812E+00  0.7947586227425416094405E+00  0.1433063833807437549572E-01 -0.9997027456229883313199E+00  0.1972443151733663593839E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2450                             0                             0                             0                             0                             0                             0
  0.2204487044621846747461E+00  0.1500082858941103047812E+00  0.8067612363196335900639E+00  0.1327870171147900457687E-01 -0.9997027456229882202976E+00  0.2044740753045124967424E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2451                             0                             0                             0                             0                             0                             0
  0.2023805587641199776883E+00  0.1500082858941103047812E+00  0.8178334102436347619047E+00  0.1219036908648369818553E-01 -0.9997027456229883313199E+00  0.2111433862080677389961E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2452                             0                             0                             0                             0                             0                             0
  0.1837577020217831536009E+00  0.1500082858941103047812E+00  0.8279447964554366157230E+00  0.1106862350716451663668E-01 -0.9997027456229881092753E+00  0.2172339677664234317001E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2453                             0                             0                             0                             0                             0                             0
  0.1646311781910456961686E+00  0.1500082858941103047812E+00  0.8370676803482666183953E+00  0.9916539600182775263115E-02 -0.9997027456229881092753E+00  0.2227291261188793849990E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2454                             0                             0                             0                             0                             0                             0
  0.1450534117442596471204E+00  0.1500082858941103047812E+00  0.8451770567314983439999E+00  0.8737275147447156123381E-02 -0.9997027456229881092753E+00  0.2276137994183551407912E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2455                             0                             0                             0                             0                             0                             0
  0.1250780639784216108357E+00  0.1500082858941103047812E+00  0.8522506983681412684462E+00  0.7534062430852934283410E-02 -0.9997027456229882202976E+00  0.2318745991148664364889E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2456                             0                             0                             0                             0                             0                             0
  0.1047598859332881798823E+00  0.1500082858941103047812E+00  0.8582692168981519431625E+00  0.6310199372821993606120E-02 -0.9997027456229881092753E+00  0.2354998466526096734253E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2457                             0                             0                             0                             0                             0                             0
  0.8415456832258215447151E-01  0.1500082858941103047812E+00  0.8632161159805820105362E+00  0.5069040496926738824379E-02 -0.9997027456229882202976E+00  0.2384796054800717574063E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2458                             0                             0                             0                             0                             0                             0
  0.6331858888961626463665E-01  0.1500082858941103047812E+00  0.8670778365089009120936E+00  0.3813987733374092810312E-02 -0.9997027456229883313199E+00  0.2408057082854270572470E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2459                             0                             0                             0                             0                             0                             0
  0.4230905760572491874916E-01  0.1500082858941103047812E+00  0.8698437937755657545225E+00  0.2548481094551294321576E-02 -0.9997027456229882202976E+00  0.2424717793825715769773E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2460                             0                             0                             0                             0                             0                             0
  0.2118356013580298402577E-01  0.1500082858941103047812E+00  0.8715064064839677104857E+00  0.1275989246191090243157E-02 -0.9997027456229882202976E+00  0.2434732521864351600938E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2461                             0                             0                             0                             0                             0                             0
  0.2045345152111577196492E-15  0.1500082858941103047812E+00  0.8720611175282400040487E+00  0.1232011239901306419149E-16 -0.9997027456229882202976E+00  0.2438073817296740330995E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2462                             0                             0                             0                             0                             0                             0
 -0.2118356013580293198406E-01  0.1500082858941103047812E+00  0.8715064064839677104857E+00 -0.1275989246191087207391E-02 -0.9997027456229881092753E+00  0.2434732521864351600938E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2463                             0                             0                             0                             0                             0                             0
 -0.4230905760572486323801E-01  0.1500082858941103047812E+00  0.8698437937755657545225E+00 -0.2548481094551291285810E-02 -0.9997027456229882202976E+00  0.2424717793825715769773E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2464                             0                             0                             0                             0                             0                             0
 -0.6331858888961622300329E-01  0.1500082858941103047812E+00  0.8670778365089009120936E+00 -0.3813987733374090208227E-02 -0.9997027456229883313199E+00  0.2408057082854270572470E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2465                             0                             0                             0                             0                             0                             0
 -0.8415456832258211283815E-01  0.1500082858941103047812E+00  0.8632161159805820105362E+00 -0.5069040496926736222294E-02 -0.9997027456229881092753E+00  0.2384796054800717574063E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2466                             0                             0                             0                             0                             0                             0
 -0.1047598859332881243711E+00  0.1500082858941103047812E+00  0.8582692168981520541848E+00 -0.6310199372821991004034E-02 -0.9997027456229883313199E+00  0.2354998466526097081197E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2467                             0                             0                             0                             0                             0                             0
 -0.1250780639784215553245E+00  0.1500082858941103047812E+00  0.8522506983681412684462E+00 -0.7534062430852931681324E-02 -0.9997027456229883313199E+00  0.2318745991148664711834E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2468                             0                             0                             0                             0                             0                             0
