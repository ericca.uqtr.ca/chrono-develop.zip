                          2817                             0                             0                             0                             0                             0                             0
  0.6285748594979115311254E-01  0.1226772314110201045345E+00  0.7630212210055065114034E+00  0.6876770260684789137784E-01 -0.9437168746105095706866E+00  0.3235266042438367795064E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2818                             0                             0                             0                             0                             0                             0
  0.4729448906722803769309E-01  0.1226772314110201045345E+00  0.7659056519839931853610E+00  0.5174138465728381902631E-01 -0.9437168746105095706866E+00  0.3266822457513096078507E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2819                             0                             0                             0                             0                             0                             0
  0.3160186127753114582184E-01  0.1226772314110201045345E+00  0.7679716256262161255819E+00  0.3457324716887352072936E-01 -0.9437168746105094596643E+00  0.3289424739305826239644E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2820                             0                             0                             0                             0                             0                             0
  0.1582261498269112165449E-01  0.1226772314110201045345E+00  0.7692134792420260991364E+00  0.1731034681313043874229E-01 -0.9437168746105093486420E+00  0.3303010936533228858458E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2821                             0                             0                             0                             0                             0                             0
  0.1527727569922398540707E-15  0.1226772314110201045345E+00  0.7696278089969823543726E+00  0.1671373164313692838966E-15 -0.9437168746105094596643E+00  0.3307543810373069770314E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2822                             0                             0                             0                             0                             0                             0
 -0.1582261498269108349057E-01  0.1226772314110201045345E+00  0.7692134792420260991364E+00 -0.1731034681313039710893E-01 -0.9437168746105093486420E+00  0.3303010936533228858458E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2823                             0                             0                             0                             0                             0                             0
 -0.3160186127753111112737E-01  0.1226772314110201045345E+00  0.7679716256262161255819E+00 -0.3457324716887348603489E-01 -0.9437168746105094596643E+00  0.3289424739305826239644E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2824                             0                             0                             0                             0                             0                             0
 -0.4729448906722800993752E-01  0.1226772314110201045345E+00  0.7659056519839931853610E+00 -0.5174138465728377739294E-01 -0.9437168746105095706866E+00  0.3266822457513096078507E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2825                             0                             0                             0                             0                             0                             0
 -0.6285748594979112535697E-01  0.1226772314110201045345E+00  0.7630212210055065114034E+00 -0.6876770260684786362226E-01 -0.9437168746105094596643E+00  0.3235266042438367795064E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2826                             0                             0                             0                             0                             0                             0
 -0.7824819483253614427198E-01  0.1226772314110201045345E+00  0.7593262387155736981015E+00 -0.8560553306355098146518E-01 -0.9437168746105095706866E+00  0.3194841988021901446615E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2827                             0                             0                             0                             0                             0                             0
 -0.9342443085221063814316E-01  0.1226772314110201045345E+00  0.7548308328038165759821E+00 -0.1022087247044946856089E+00 -0.9437168746105095706866E+00  0.3145661093787009976452E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2828                             0                             0                             0                             0                             0                             0
 -0.1083445970007716613326E+00  0.1226772314110201045345E+00  0.7495473248653672371233E+00 -0.1185317693354645679493E+00 -0.9437168746105094596643E+00  0.3087858161146270763453E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2829                             0                             0                             0                             0                             0                             0
 -0.1229677981398943076297E+00  0.1226772314110201045345E+00  0.7434901966282330132429E+00 -0.1345299266257283798964E+00 -0.9437168746105094596643E+00  0.3021591623920217850596E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2830                             0                             0                             0                             0                             0                             0
 -0.1372539530917022132517E+00  0.1226772314110201045345E+00  0.7366760502598859172707E+00 -0.1501593467381714397391E+00 -0.9437168746105093486420E+00  0.2947043114081259185255E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2831                             0                             0                             0                             0                             0                             0
 -0.1511639044984910973390E+00  0.1226772314110201045345E+00  0.7291235628618761843711E+00 -0.1653771905186534052490E+00 -0.9437168746105093486420E+00  0.2864416963913058444824E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2832                             0                             0                             0                             0                             0                             0
 -0.1646595261503238649681E+00  0.1226772314110201045345E+00  0.7208534352771948094940E+00 -0.1801417469151514461068E+00 -0.9437168746105093486420E+00  0.2773939645949953791693E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2833                             0                             0                             0                             0                             0                             0
 -0.1777038274863218525468E+00  0.1226772314110201045345E+00  0.7118883353507018396655E+00 -0.1944125473048542440679E+00 -0.9437168746105093486420E+00  0.2675859152231482296358E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2834                             0                             0                             0                             0                             0                             0
 -0.1902610549832214059673E+00  0.1226772314110201045345E+00  0.7022528357981392410636E+00 -0.2081504764158449150013E+00 -0.9437168746105093486420E+00  0.2570444314573432920135E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2835                             0                             0                             0                             0                             0                             0
 -0.2022967901532958523436E+00  0.1226772314110201045345E+00  0.6919733468540254506252E+00 -0.2213178795393420661419E+00 -0.9437168746105094596643E+00  0.2457984067718530507562E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2836                             0                             0                             0                             0                             0                             0
 -0.2137780438830374774017E+00  0.1226772314110201045345E+00  0.6810780438830374983183E+00 -0.2338786657386389689073E+00 -0.9437168746105093486420E+00  0.2338786657386389966629E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2837                             0                             0                             0                             0                             0                             0
 -0.2246733468540253186863E+00  0.1226772314110201045345E+00  0.6695967901532958732602E+00 -0.2457984067718529674895E+00 -0.9437168746105093486420E+00  0.2213178795393420938975E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2838                             0                             0                             0                             0                             0                             0
 -0.2349528357981391923914E+00  0.1226772314110201045345E+00  0.6575610549832215934174E+00 -0.2570444314573431809912E+00 -0.9437168746105095706866E+00  0.2081504764158450537792E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2839                             0                             0                             0                             0                             0                             0
 -0.2445883353507017909934E+00  0.1226772314110201045345E+00  0.6450038274863219012190E+00 -0.2675859152231481741246E+00 -0.9437168746105093486420E+00  0.1944125473048542995791E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2840                             0                             0                             0                             0                             0                             0
 -0.2535534352771948718441E+00  0.1226772314110201045345E+00  0.6319595261503238026179E+00 -0.2773939645949954901916E+00 -0.9437168746105095706866E+00  0.1801417469151514183512E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2841                             0                             0                             0                             0                             0                             0
 -0.2618235628618761912101E+00  0.1226772314110201045345E+00  0.6184639044984912015224E+00 -0.2864416963913057889712E+00 -0.9437168746105095706866E+00  0.1653771905186535995380E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2842                             0                             0                             0                             0                             0                             0
 -0.2693760502598859241097E+00  0.1226772314110201045345E+00  0.6045539530917022341683E+00 -0.2947043114081258630144E+00 -0.9437168746105093486420E+00  0.1501593467381714952502E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2843                             0                             0                             0                             0                             0                             0
 -0.2761901966282329645708E+00  0.1226772314110201045345E+00  0.5902677981398944950797E+00 -0.3021591623920217295485E+00 -0.9437168746105094596643E+00  0.1345299266257285464299E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2844                             0                             0                             0                             0                             0                             0
 -0.2822473248653673549846E+00  0.1226772314110201045345E+00  0.5756445970007715295935E+00 -0.3087858161146270763453E+00 -0.9437168746105095706866E+00  0.1185317693354644985604E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2845                             0                             0                             0                             0                             0                             0
 -0.2875308328038165828211E+00  0.1226772314110201045345E+00  0.5607244308522106868153E+00 -0.3145661093787009421341E+00 -0.9437168746105094596643E+00  0.1022087247044947411201E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2846                             0                             0                             0                             0                             0                             0
 -0.2920262387155737604516E+00  0.1226772314110201045345E+00  0.5455481948325361374330E+00 -0.3194841988021900891503E+00 -0.9437168746105093486420E+00  0.8560553306355102309855E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2847                             0                             0                             0                             0                             0                             0
 -0.2957212210055064627312E+00  0.1226772314110201045345E+00  0.5301574859497912850514E+00 -0.3235266042438367239953E+00 -0.9437168746105094596643E+00  0.6876770260684805791129E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2848                             0                             0                             0                             0                             0                             0
 -0.2986056519839931922000E+00  0.1226772314110201045345E+00  0.5145944890672280447319E+00 -0.3266822457513096078507E+00 -0.9437168746105093486420E+00  0.5174138465728383290410E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2849                             0                             0                             0                             0                             0                             0
 -0.3006716256262161324209E+00  0.1226772314110201045345E+00  0.4989018612775314442942E+00 -0.3289424739305826239644E+00 -0.9437168746105094596643E+00  0.3457324716887383297959E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2850                             0                             0                             0                             0                             0                             0
 -0.3019134792420261614865E+00  0.1226772314110201045345E+00  0.4831226149826909899154E+00 -0.3303010936533229413570E+00 -0.9437168746105095706866E+00  0.1731034681313031384220E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2851                             0                             0                             0                             0                             0                             0
 -0.3023278089969823057004E+00  0.1226772314110201045345E+00  0.4673000000000000486722E+00 -0.3307543810373069770314E+00 -0.9437168746105094596643E+00  0.4050572940413020137087E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2852                             0                             0                             0                             0                             0                             0
 -0.3019134792420261059753E+00  0.1226772314110201045345E+00  0.4514773850173087743620E+00 -0.3303010936533228858458E+00 -0.9437168746105093486420E+00 -0.1731034681313052547846E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2853                             0                             0                             0                             0                             0                             0
 -0.3006716256262161879320E+00  0.1226772314110201045345E+00  0.4356981387224688750948E+00 -0.3289424739305826239644E+00 -0.9437168746105094596643E+00 -0.3457324716887346521821E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2854                             0                             0                             0                             0                             0                             0
 -0.2986056519839931922000E+00  0.1226772314110201045345E+00  0.4200055109327719971013E+00 -0.3266822457513096078507E+00 -0.9437168746105095706866E+00 -0.5174138465728374963737E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2855                             0                             0                             0                             0                             0                             0
 -0.2957212210055064627312E+00  0.1226772314110201045345E+00  0.4044425140502087567818E+00 -0.3235266042438367239953E+00 -0.9437168746105094596643E+00 -0.6876770260684798852235E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2856                             0                             0                             0                             0                             0                             0
 -0.2920262387155737049405E+00  0.1226772314110201045345E+00  0.3890518051674636268444E+00 -0.3194841988021900336392E+00 -0.9437168746105094596643E+00 -0.8560553306355123126536E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2857                             0                             0                             0                             0                             0                             0
 -0.2875308328038165828211E+00  0.1226772314110201045345E+00  0.3738755691477893550179E+00 -0.3145661093787009976452E+00 -0.9437168746105095706866E+00 -0.1022087247044946578534E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2858                             0                             0                             0                             0                             0                             0
 -0.2822473248653673549846E+00  0.1226772314110201045345E+00  0.3589554029992284567285E+00 -0.3087858161146270763453E+00 -0.9437168746105094596643E+00 -0.1185317693354644291714E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2859                             0                             0                             0                             0                             0                             0
 -0.2761901966282330755931E+00  0.1226772314110201045345E+00  0.3443322018601058243092E+00 -0.3021591623920218405708E+00 -0.9437168746105095706866E+00 -0.1345299266257282133630E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2860                             0                             0                             0                             0                             0                             0
 -0.2693760502598859796208E+00  0.1226772314110201045345E+00  0.3300460469082977521538E+00 -0.2947043114081259185255E+00 -0.9437168746105093486420E+00 -0.1501593467381714397391E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2861                             0                             0                             0                             0                             0                             0
 -0.2618235628618762467212E+00  0.1226772314110201045345E+00  0.3161360955015087847997E+00 -0.2864416963913058444824E+00 -0.9437168746105094596643E+00 -0.1653771905186535162713E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2862                             0                             0                             0                             0                             0                             0
 -0.2535534352771949273553E+00  0.1226772314110201045345E+00  0.3026404738496762392153E+00 -0.2773939645949954901916E+00 -0.9437168746105095706866E+00 -0.1801417469151513350845E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2863                             0                             0                             0                             0                             0                             0
 -0.2445883353507018465045E+00  0.1226772314110201045345E+00  0.2895961725136781406142E+00 -0.2675859152231482296358E+00 -0.9437168746105095706866E+00 -0.1944125473048542440679E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2864                             0                             0                             0                             0                             0                             0
 -0.2349528357981394144360E+00  0.1226772314110201045345E+00  0.2770389450167787259716E+00 -0.2570444314573434030358E+00 -0.9437168746105093486420E+00 -0.2081504764158447762235E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2865                             0                             0                             0                             0                             0                             0
 -0.2246733468540252909307E+00  0.1226772314110201045345E+00  0.2650032098467040575507E+00 -0.2457984067718529397339E+00 -0.9437168746105094596643E+00 -0.2213178795393421771642E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2866                             0                             0                             0                             0                             0                             0
 -0.2137780438830375606685E+00  0.1226772314110201045345E+00  0.2535219561169624880037E+00 -0.2338786657386390521740E+00 -0.9437168746105095706866E+00 -0.2338786657386389689073E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2867                             0                             0                             0                             0                             0                             0
 -0.2022967901532958245880E+00  0.1226772314110201045345E+00  0.2426266531459745634525E+00 -0.2213178795393420106308E+00 -0.9437168746105095706866E+00 -0.2457984067718530785118E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2868                             0                             0                             0                             0                             0                             0
 -0.1902610549832215725008E+00  0.1226772314110201045345E+00  0.2323471642018608285252E+00 -0.2081504764158450815348E+00 -0.9437168746105094596643E+00 -0.2570444314573431254800E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2869                             0                             0                             0                             0                             0                             0
 -0.1777038274863219080579E+00  0.1226772314110201045345E+00  0.2227116646492982021677E+00 -0.1944125473048542995791E+00 -0.9437168746105093486420E+00 -0.2675859152231481741246E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2870                             0                             0                             0                             0                             0                             0
 -0.1646595261503240592571E+00  0.1226772314110201045345E+00  0.2137465647228052878503E+00 -0.1801417469151516681514E+00 -0.9437168746105095706866E+00 -0.2773939645949952681470E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2871                             0                             0                             0                             0                             0                             0
 -0.1511639044984910418279E+00  0.1226772314110201045345E+00  0.2054764371381236909286E+00 -0.1653771905186533497378E+00 -0.9437168746105093486420E+00 -0.2864416963913058999935E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2872                             0                             0                             0                             0                             0                             0
 -0.1372539530917022965184E+00  0.1226772314110201045345E+00  0.1979239497401140690513E+00 -0.1501593467381715230058E+00 -0.9437168746105094596643E+00 -0.2947043114081258630144E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2873                             0                             0                             0                             0                             0                             0
 -0.1229677981398942521185E+00  0.1226772314110201045345E+00  0.1911098033717669175680E+00 -0.1345299266257283243853E+00 -0.9437168746105095706866E+00 -0.3021591623920218405708E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2874                             0                             0                             0                             0                             0                             0
 -0.1083445970007718694994E+00  0.1226772314110201045345E+00  0.1850526751346327491987E+00 -0.1185317693354647899939E+00 -0.9437168746105094596643E+00 -0.3087858161146269653230E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2875                             0                             0                             0                             0                             0                             0
 -0.9342443085221070753210E-01  0.1226772314110201045345E+00  0.1797691671961834103399E+00 -0.1022087247044947549979E+00 -0.9437168746105094596643E+00 -0.3145661093787009421341E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2876                             0                             0                             0                             0                             0                             0
 -0.7824819483253619978314E-01  0.1226772314110201045345E+00  0.1752737612844262327094E+00 -0.8560553306355105085412E-01 -0.9437168746105094596643E+00 -0.3194841988021900891503E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2877                             0                             0                             0                             0                             0                             0
 -0.6285748594979105596803E-01  0.1226772314110201045345E+00  0.1715787789944934749187E+00 -0.6876770260684779423332E-01 -0.9437168746105094596643E+00 -0.3235266042438367795064E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2878                             0                             0                             0                             0                             0                             0
 -0.4729448906722807238756E-01  0.1226772314110201045345E+00  0.1686943480160068009610E+00 -0.5174138465728385372078E-01 -0.9437168746105093486420E+00 -0.3266822457513096078507E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2879                             0                             0                             0                             0                             0                             0
 -0.3160186127753118745520E-01  0.1226772314110201045345E+00  0.1666283743737838052290E+00 -0.3457324716887356236272E-01 -0.9437168746105094596643E+00 -0.3289424739305826239644E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2880                             0                             0                             0                             0                             0                             0
 -0.1582261498269129165739E-01  0.1226772314110201045345E+00  0.1653865207579738871857E+00 -0.1731034681313062609243E-01 -0.9437168746105094596643E+00 -0.3303010936533228858458E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2881                             0                             0                             0                             0                             0                             0
  0.1642863681056174140932E-16  0.1150000000000000049960E+00  0.1990000000000000102141E+00  0.3548016375458390791401E-17 -0.9983198637050665347203E+00 -0.5794350465666767147077E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2882                             0                             0                             0                             0                             0                             0
  0.1404173705998186527655E-01  0.1150000000000000049960E+00  0.1993676958253478570526E+00  0.3032528724274179306175E-02 -0.9983198637050664236980E+00 -0.5786409509733751732607E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2883                             0                             0                             0                             0                             0                             0
  0.2804498669471142124898E-01  0.1150000000000000049960E+00  0.2004697754726922909185E+00  0.6056745498103593625117E-02 -0.9983198637050664236980E+00 -0.5762608407542950395008E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2884                             0                             0                             0                             0                             0                             0
  0.4197136697029395235869E-01  0.1150000000000000049960E+00  0.2023032182183245319962E+00  0.9064361153521936428912E-02 -0.9983198637050666457426E+00 -0.5723012396261072803894E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2885                             0                             0                             0                             0                             0                             0
  0.5578270664640485460017E-01  0.1150000000000000049960E+00  0.2048629987231199711673E+00  0.1204713202507449489043E-01 -0.9983198637050664236980E+00 -0.5667730005802757570210E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2886                             0                             0                             0                             0                             0                             0
  0.6944114980100631051574E-01  0.1150000000000000049960E+00  0.2081421008066429712002E+00  0.1499688254513219069775E-01 -0.9983198637050665347203E+00 -0.5596912761357619725544E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2887                             0                             0                             0                             0                             0                             0
  0.8290925959079839535626E-01  0.1150000000000000049960E+00  0.2121315366780103239819E+00  0.1790552765255421646673E-01 -0.9983198637050664236980E+00 -0.5510754768070236231381E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2888                             0                             0                             0                             0                             0                             0
  0.9615012086300409044348E-01  0.1150000000000000049960E+00  0.2168203715708008072482E+00  0.2076509495327855808755E-01 -0.9983198637050665347203E+00 -0.5409492179011440166070E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2889                             0                             0                             0                             0                             0                             0
  0.1091274413372371882014E+00  0.1150000000000000049960E+00  0.2221957537144901850823E+00  0.2356774657210000678553E-01 -0.9983198637050664236980E+00 -0.5293402547899164062306E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2890                             0                             0                             0                             0                             0                             0
  0.1218056510801203973227E+00  0.1150000000000000049960E+00  0.2282429495602609215155E+00  0.2630580063574131446935E-01 -0.9983198637050663126757E+00 -0.5162804068342996544061E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2891                             0                             0                             0                             0                             0                             0
  0.1341499999999999637179E+00  0.1150000000000000049960E+00  0.2349453841646350904515E+00  0.2897175232833382879649E-01 -0.9983198637050665347203E+00 -0.5018054701697612779432E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2892                             0                             0                             0                             0                             0                             0
  0.1461266530945317665413E+00  0.1150000000000000049960E+00  0.2422846866202427451586E+00  0.3155829446159620632617E-01 -0.9983198637050665347203E+00 -0.4859551195915579741014E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2893                             0                             0                             0                             0                             0                             0
  0.1577027831900705279189E+00  0.1150000000000000049960E+00  0.2502407404092016340869E+00  0.3405833750332949716455E-01 -0.9983198637050665347203E+00 -0.4687727998088805220211E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2894                             0                             0                             0                             0                             0                             0
  0.1688466609186713984769E+00  0.1150000000000000049960E+00  0.2587917385410947179736E+00  0.3646502900933217689028E-01 -0.9983198637050664236980E+00 -0.4503056063659246349706E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2895                             0                             0                             0                             0                             0                             0
  0.1795277416860816543931E+00  0.1150000000000000049960E+00  0.2679142433244151577654E+00  0.3877177240547336617427E-01 -0.9983198637050664236980E+00 -0.4306041565562786915811E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2896                             0                             0                             0                             0                             0                             0
  0.1897167493923506698117E+00  0.1150000000000000049960E+00  0.2775832506076493233493E+00  0.4097224506844399788408E-01 -0.9983198637050665347203E+00 -0.4097224506844400482297E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2897                             0                             0                             0                             0                             0                             0
  0.1993857566755848631512E+00  0.1150000000000000049960E+00  0.2877722583139183387679E+00  0.4306041565562787609700E-01 -0.9983198637050665347203E+00 -0.3877177240547336617427E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2898                             0                             0                             0                             0                             0                             0
  0.2085082614589052751874E+00  0.1150000000000000049960E+00  0.2984533390813286501952E+00  0.4503056063659247043596E-01 -0.9983198637050665347203E+00 -0.3646502900933216995139E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2899                             0                             0                             0                             0                             0                             0
  0.2170592595907983868297E+00  0.1150000000000000049960E+00  0.3095972168099294652421E+00  0.4687727998088805220211E-01 -0.9983198637050665347203E+00 -0.3405833750332949716455E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2900                             0                             0                             0                             0                             0                             0
  0.2250153133797572480024E+00  0.1150000000000000049960E+00  0.3211733469054682266197E+00  0.4859551195915579741014E-01 -0.9983198637050665347203E+00 -0.3155829446159620632617E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2901                             0                             0                             0                             0                             0                             0
  0.2323546158353648471984E+00  0.1150000000000000049960E+00  0.3331500000000000016875E+00  0.5018054701697612085542E-01 -0.9983198637050664236980E+00 -0.2897175232833383573539E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2902                             0                             0                             0                             0                             0                             0
  0.2390570504397390994011E+00  0.1150000000000000049960E+00  0.3454943489198796235939E+00  0.5162804068342997237950E-01 -0.9983198637050665347203E+00 -0.2630580063574131099990E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2903                             0                             0                             0                             0                             0                             0
  0.2451042462855098080787E+00  0.1150000000000000049960E+00  0.3581725586627627633263E+00  0.5293402547899164062306E-01 -0.9983198637050665347203E+00 -0.2356774657210001372443E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2904                             0                             0                             0                             0                             0                             0
  0.2504796284291991859128E+00  0.1150000000000000049960E+00  0.3711498791369959304731E+00  0.5409492179011440166070E-01 -0.9983198637050665347203E+00 -0.2076509495327855461810E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2905                             0                             0                             0                             0                             0                             0
  0.2551684633219896691791E+00  0.1150000000000000049960E+00  0.3843907404092016255603E+00  0.5510754768070236231381E-01 -0.9983198637050664236980E+00 -0.1790552765255421299728E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2906                             0                             0                             0                             0                             0                             0
  0.2591578991933570219608E+00  0.1150000000000000049960E+00  0.3978588501989936965231E+00  0.5596912761357619725544E-01 -0.9983198637050665347203E+00 -0.1499688254513218722830E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2907                             0                             0                             0                             0                             0                             0
  0.2624370012768800219938E+00  0.1150000000000000049960E+00  0.4115172933535952148887E+00  0.5667730005802758264100E-01 -0.9983198637050665347203E+00 -0.1204713202507447754319E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2908                             0                             0                             0                             0                             0                             0
  0.2649967817816754611648E+00  0.1150000000000000049960E+00  0.4253286330297060269245E+00  0.5723012396261072803894E-01 -0.9983198637050666457426E+00 -0.9064361153521932959465E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2909                             0                             0                             0                             0                             0                             0
  0.2668302245273077022425E+00  0.1150000000000000049960E+00  0.4392550133052885996676E+00  0.5762608407542950395008E-01 -0.9983198637050664236980E+00 -0.6056745498103589288308E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2910                             0                             0                             0                             0                             0                             0
  0.2679323041746521361084E+00  0.1150000000000000049960E+00  0.4532582629400181972734E+00  0.5786409509733751732607E-01 -0.9983198637050664236980E+00 -0.3032528724274162826302E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2911                             0                             0                             0                             0                             0                             0
  0.2682999999999999829470E+00  0.1150000000000000049960E+00  0.4672999999999999376499E+00  0.5794350465666767147077E-01 -0.9983198637050665347203E+00 -0.1286604259946148497890E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2912                             0                             0                             0                             0                             0                             0
  0.2679323041746521361084E+00  0.1150000000000000049960E+00  0.4813417370599817890486E+00  0.5786409509733751732607E-01 -0.9983198637050664236980E+00  0.3032528724274162826302E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2913                             0                             0                             0                             0                             0                             0
  0.2668302245273077022425E+00  0.1150000000000000049960E+00  0.4953449866947113866544E+00  0.5762608407542950395008E-01 -0.9983198637050664236980E+00  0.6056745498103589288308E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2914                             0                             0                             0                             0                             0                             0
  0.2649967817816754611648E+00  0.1150000000000000049960E+00  0.5092713669702939593975E+00  0.5723012396261072803894E-01 -0.9983198637050666457426E+00  0.9064361153521932959465E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2915                             0                             0                             0                             0                             0                             0
  0.2624370012768800219938E+00  0.1150000000000000049960E+00  0.5230827066464048824557E+00  0.5667730005802757570210E-01 -0.9983198637050664236980E+00  0.1204713202507449142098E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2916                             0                             0                             0                             0                             0                             0
  0.2591578991933570219608E+00  0.1150000000000000049960E+00  0.5367411498010062897990E+00  0.5596912761357619725544E-01 -0.9983198637050665347203E+00  0.1499688254513218722830E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2917                             0                             0                             0                             0                             0                             0
  0.2551684633219896691791E+00  0.1150000000000000049960E+00  0.5502092595907983607617E+00  0.5510754768070236231381E-01 -0.9983198637050664236980E+00  0.1790552765255421299728E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2918                             0                             0                             0                             0                             0                             0
  0.2504796284291991859128E+00  0.1150000000000000049960E+00  0.5634501208630040558489E+00  0.5409492179011440166070E-01 -0.9983198637050665347203E+00  0.2076509495327855461810E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2919                             0                             0                             0                             0                             0                             0
  0.2451042462855098358343E+00  0.1150000000000000049960E+00  0.5764274413372372229958E+00  0.5293402547899164756195E-01 -0.9983198637050666457426E+00  0.2356774657210000331609E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2920                             0                             0                             0                             0                             0                             0
  0.2390570504397390994011E+00  0.1150000000000000049960E+00  0.5891056510801203627281E+00  0.5162804068342997237950E-01 -0.9983198637050665347203E+00  0.2630580063574131099990E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2921                             0                             0                             0                             0                             0                             0
  0.2323546158353649027095E+00  0.1150000000000000049960E+00  0.6014499999999999291234E+00  0.5018054701697612779432E-01 -0.9983198637050665347203E+00  0.2897175232833382532704E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2922                             0                             0                             0                             0                             0                             0
  0.2250153133797572757580E+00  0.1150000000000000049960E+00  0.6134266530945317041912E+00  0.4859551195915580434903E-01 -0.9983198637050665347203E+00  0.3155829446159619938728E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2923                             0                             0                             0                             0                             0                             0
  0.2170592595907983868297E+00  0.1150000000000000049960E+00  0.6250027831900705210799E+00  0.4687727998088805220211E-01 -0.9983198637050665347203E+00  0.3405833750332949716455E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2924                             0                             0                             0                             0                             0                             0
  0.2085082614589053029430E+00  0.1150000000000000049960E+00  0.6361466609186713361268E+00  0.4503056063659247737485E-01 -0.9983198637050664236980E+00  0.3646502900933216301249E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2925                             0                             0                             0                             0                             0                             0
  0.1993857566755849186624E+00  0.1150000000000000049960E+00  0.6468277416860815920430E+00  0.4306041565562788997479E-01 -0.9983198637050665347203E+00  0.3877177240547335229648E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2926                             0                             0                             0                             0                             0                             0
  0.1897167493923506975673E+00  0.1150000000000000049960E+00  0.6570167493923506629727E+00  0.4097224506844400482297E-01 -0.9983198637050665347203E+00  0.4097224506844399788408E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2927                             0                             0                             0                             0                             0                             0
  0.1795277416860816821487E+00  0.1150000000000000049960E+00  0.6666857566755848285567E+00  0.3877177240547337311316E-01 -0.9983198637050665347203E+00  0.4306041565562786915811E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2928                             0                             0                             0                             0                             0                             0
  0.1688466609186713707214E+00  0.1150000000000000049960E+00  0.6758082614589052683485E+00  0.3646502900933216995139E-01 -0.9983198637050665347203E+00  0.4503056063659247043596E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2929                             0                             0                             0                             0                             0                             0
  0.1577027831900705279189E+00  0.1150000000000000049960E+00  0.6843592595907983522352E+00  0.3405833750332949716455E-01 -0.9983198637050665347203E+00  0.4687727998088805220211E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2930                             0                             0                             0                             0                             0                             0
  0.1461266530945317942969E+00  0.1150000000000000049960E+00  0.6923153133797572689190E+00  0.3155829446159621326506E-01 -0.9983198637050665347203E+00  0.4859551195915579047124E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2931                             0                             0                             0                             0                             0                             0
  0.1341499999999999637179E+00  0.1150000000000000049960E+00  0.6996546158353649236261E+00  0.2897175232833382879649E-01 -0.9983198637050665347203E+00  0.5018054701697612779432E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2932                             0                             0                             0                             0                             0                             0
  0.1218056510801203973227E+00  0.1150000000000000049960E+00  0.7063570504397390648066E+00  0.2630580063574131446935E-01 -0.9983198637050663126757E+00  0.5162804068342996544061E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2933                             0                             0                             0                             0                             0                             0
  0.1091274413372371326902E+00  0.1150000000000000049960E+00  0.7124042462855098012398E+00  0.2356774657209999290775E-01 -0.9983198637050665347203E+00  0.5293402547899164756195E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2934                             0                             0                             0                             0                             0                             0
  0.9615012086300402105454E-01  0.1150000000000000049960E+00  0.7177796284291991790738E+00  0.2076509495327854420976E-01 -0.9983198637050663126757E+00  0.5409492179011440166070E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2935                             0                             0                             0                             0                             0                             0
  0.8290925959079839535626E-01  0.1150000000000000049960E+00  0.7224684633219896623402E+00  0.1790552765255421646673E-01 -0.9983198637050664236980E+00  0.5510754768070236231381E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2936                             0                             0                             0                             0                             0                             0
  0.6944114980100625500459E-01  0.1150000000000000049960E+00  0.7264578991933570151218E+00  0.1499688254513217855468E-01 -0.9983198637050664236980E+00  0.5596912761357619725544E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2937                             0                             0                             0                             0                             0                             0
  0.5578270664640479908902E-01  0.1150000000000000049960E+00  0.7297370012768800151548E+00  0.1204713202507448101264E-01 -0.9983198637050665347203E+00  0.5667730005802758264100E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2938                             0                             0                             0                             0                             0                             0
  0.4197136697029395235869E-01  0.1150000000000000049960E+00  0.7322967817816754543259E+00  0.9064361153521936428912E-02 -0.9983198637050666457426E+00  0.5723012396261072803894E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2939                             0                             0                             0                             0                             0                             0
  0.2804498669471136226838E-01  0.1150000000000000049960E+00  0.7341302245273078064258E+00  0.6056745498103580614691E-02 -0.9983198637050666457426E+00  0.5762608407542951088898E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2940                             0                             0                             0                             0                             0                             0
  0.1404173705998180629595E-01  0.1150000000000000049960E+00  0.7352323041746521292694E+00  0.3032528724274166295749E-02 -0.9983198637050664236980E+00  0.5786409509733751732607E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2941                             0                             0                             0                             0                             0                             0
  0.1355777718133335429990E-15  0.1150000000000000049960E+00  0.7356000000000000316192E+00  0.2928010157438135920846E-16 -0.9983198637050665347203E+00  0.5794350465666767147077E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2942                             0                             0                             0                             0                             0                             0
 -0.1404173705998177160148E-01  0.1150000000000000049960E+00  0.7352323041746521292694E+00 -0.3032528724274158923174E-02 -0.9983198637050664236980E+00  0.5786409509733751732607E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2943                             0                             0                             0                             0                             0                             0
 -0.2804498669471132757391E-01  0.1150000000000000049960E+00  0.7341302245273078064258E+00 -0.6056745498103573675797E-02 -0.9983198637050665347203E+00  0.5762608407542951088898E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2944                             0                             0                             0                             0                             0                             0
 -0.4197136697029392460312E-01  0.1150000000000000049960E+00  0.7322967817816754543259E+00 -0.9064361153521929490018E-02 -0.9983198637050665347203E+00  0.5723012396261072803894E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2945                             0                             0                             0                             0                             0                             0
 -0.5578270664640477133345E-01  0.1150000000000000049960E+00  0.7297370012768800151548E+00 -0.1204713202507447407374E-01 -0.9983198637050665347203E+00  0.5667730005802758264100E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2946                             0                             0                             0                             0                             0                             0
 -0.6944114980100622724901E-01  0.1150000000000000049960E+00  0.7264578991933570151218E+00 -0.1499688254513217161579E-01 -0.9983198637050665347203E+00  0.5596912761357620419433E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2947                             0                             0                             0                             0                             0                             0
 -0.8290925959079836760068E-01  0.1150000000000000049960E+00  0.7224684633219897733625E+00 -0.1790552765255420952784E-01 -0.9983198637050665347203E+00  0.5510754768070236925270E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2948                             0                             0                             0                             0                             0                             0
 -0.9615012086300399329897E-01  0.1150000000000000049960E+00  0.7177796284291992900961E+00 -0.2076509495327853727087E-01 -0.9983198637050665347203E+00  0.5409492179011440859959E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2949                             0                             0                             0                             0                             0                             0
 -0.1091274413372372020792E+00  0.1150000000000000049960E+00  0.7124042462855098012398E+00 -0.2356774657210001025498E-01 -0.9983198637050665347203E+00  0.5293402547899164062306E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2950                             0                             0                             0                             0                             0                             0
 -0.1218056510801203695671E+00  0.1150000000000000049960E+00  0.7063570504397390648066E+00 -0.2630580063574130753046E-01 -0.9983198637050665347203E+00  0.5162804068342997237950E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2951                             0                             0                             0                             0                             0                             0
 -0.1341499999999999359623E+00  0.1150000000000000049960E+00  0.6996546158353649236261E+00 -0.2897175232833382185760E-01 -0.9983198637050664236980E+00  0.5018054701697612779432E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2952                             0                             0                             0                             0                             0                             0
 -0.1461266530945317665413E+00  0.1150000000000000049960E+00  0.6923153133797572689190E+00 -0.3155829446159620632617E-01 -0.9983198637050664236980E+00  0.4859551195915579047124E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2953                             0                             0                             0                             0                             0                             0
 -0.1577027831900705001633E+00  0.1150000000000000049960E+00  0.6843592595907983522352E+00 -0.3405833750332949022566E-01 -0.9983198637050665347203E+00  0.4687727998088805220211E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2954                             0                             0                             0                             0                             0                             0
 -0.1688466609186713429658E+00  0.1150000000000000049960E+00  0.6758082614589052683485E+00 -0.3646502900933216301249E-01 -0.9983198637050664236980E+00  0.4503056063659247737485E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2955                             0                             0                             0                             0                             0                             0
 -0.1795277416860816543931E+00  0.1150000000000000049960E+00  0.6666857566755848285567E+00 -0.3877177240547336617427E-01 -0.9983198637050665347203E+00  0.4306041565562787609700E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2956                             0                             0                             0                             0                             0                             0
 -0.1897167493923506698117E+00  0.1150000000000000049960E+00  0.6570167493923506629727E+00 -0.4097224506844399788408E-01 -0.9983198637050665347203E+00  0.4097224506844400482297E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2957                             0                             0                             0                             0                             0                             0
 -0.1993857566755848076401E+00  0.1150000000000000049960E+00  0.6468277416860817030653E+00 -0.4306041565562786221921E-01 -0.9983198637050663126757E+00  0.3877177240547337311316E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2958                             0                             0                             0                             0                             0                             0
 -0.2085082614589052196763E+00  0.1150000000000000049960E+00  0.6361466609186714471491E+00 -0.4503056063659245655817E-01 -0.9983198637050665347203E+00  0.3646502900933219076807E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2959                             0                             0                             0                             0                             0                             0
 -0.2170592595907983590742E+00  0.1150000000000000049960E+00  0.6250027831900705210799E+00 -0.4687727998088804526322E-01 -0.9983198637050665347203E+00  0.3405833750332950410344E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2960                             0                             0                             0                             0                             0                             0
 -0.2250153133797572757580E+00  0.1150000000000000049960E+00  0.6134266530945317041912E+00 -0.4859551195915580434903E-01 -0.9983198637050665347203E+00  0.3155829446159619938728E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2961                             0                             0                             0                             0                             0                             0
 -0.2323546158353648194428E+00  0.1150000000000000049960E+00  0.6014500000000000401457E+00 -0.5018054701697611391653E-01 -0.9983198637050665347203E+00  0.2897175232833385655207E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2962                             0                             0                             0                             0                             0                             0
 -0.2390570504397390716456E+00  0.1150000000000000049960E+00  0.5891056510801203627281E+00 -0.5162804068342996544061E-01 -0.9983198637050664236980E+00  0.2630580063574131793880E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2963                             0                             0                             0                             0                             0                             0
 -0.2451042462855097248120E+00  0.1150000000000000049960E+00  0.5764274413372373340181E+00 -0.5293402547899162674527E-01 -0.9983198637050666457426E+00  0.2356774657210004148000E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2964                             0                             0                             0                             0                             0                             0
 -0.2504796284291992969351E+00  0.1150000000000000049960E+00  0.5634501208630039448266E+00 -0.5409492179011441553849E-01 -0.9983198637050665347203E+00  0.2076509495327852686253E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2965                             0                             0                             0                             0                             0                             0
 -0.2551684633219896691791E+00  0.1150000000000000049960E+00  0.5502092595907983607617E+00 -0.5510754768070236231381E-01 -0.9983198637050664236980E+00  0.1790552765255421993618E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2966                             0                             0                             0                             0                             0                             0
 -0.2591578991933570219608E+00  0.1150000000000000049960E+00  0.5367411498010062897990E+00 -0.5596912761357619725544E-01 -0.9983198637050664236980E+00  0.1499688254513218028940E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2967                             0                             0                             0                             0                             0                             0
 -0.2624370012768800219938E+00  0.1150000000000000049960E+00  0.5230827066464048824557E+00 -0.5667730005802757570210E-01 -0.9983198637050665347203E+00  0.1204713202507451050294E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2968                             0                             0                             0                             0                             0                             0
 -0.2649967817816754056537E+00  0.1150000000000000049960E+00  0.5092713669702939593975E+00 -0.5723012396261072110004E-01 -0.9983198637050664236980E+00  0.9064361153521939898359E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2969                             0                             0                             0                             0                             0                             0
 -0.2668302245273077022425E+00  0.1150000000000000049960E+00  0.4953449866947116086990E+00 -0.5762608407542950395008E-01 -0.9983198637050665347203E+00  0.6056745498103635258480E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2970                             0                             0                             0                             0                             0                             0
 -0.2679323041746521916195E+00  0.1150000000000000049960E+00  0.4813417370599816780263E+00 -0.5786409509733752426497E-01 -0.9983198637050666457426E+00  0.3032528724274144178025E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2971                             0                             0                             0                             0                             0                             0
 -0.2682999999999999829470E+00  0.1150000000000000049960E+00  0.4673000000000000486722E+00 -0.5794350465666767147077E-01 -0.9983198637050665347203E+00  0.7096032750916781582801E-17
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2972                             0                             0                             0                             0                             0                             0
 -0.2679323041746521361084E+00  0.1150000000000000049960E+00  0.4532582629400181417623E+00 -0.5786409509733751732607E-01 -0.9983198637050664236980E+00 -0.3032528724274181040899E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2973                             0                             0                             0                             0                             0                             0
 -0.2668302245273077577536E+00  0.1150000000000000049960E+00  0.4392550133052886551788E+00 -0.5762608407542951088898E-01 -0.9983198637050665347203E+00 -0.6056745498103570206350E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2974                             0                             0                             0                             0                             0                             0
 -0.2649967817816754611648E+00  0.1150000000000000049960E+00  0.4253286330297060824357E+00 -0.5723012396261072803894E-01 -0.9983198637050665347203E+00 -0.9064361153521926020571E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2975                             0                             0                             0                             0                             0                             0
 -0.2624370012768800219938E+00  0.1150000000000000049960E+00  0.4115172933535951038664E+00 -0.5667730005802757570210E-01 -0.9983198637050664236980E+00 -0.1204713202507449662515E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2976                             0                             0                             0                             0                             0                             0
 -0.2591578991933569664496E+00  0.1150000000000000049960E+00  0.3978588501989935855008E+00 -0.5596912761357619031655E-01 -0.9983198637050665347203E+00 -0.1499688254513221671860E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2977                             0                             0                             0                             0                             0                             0
 -0.2551684633219897246903E+00  0.1150000000000000049960E+00  0.3843907404092016255603E+00 -0.5510754768070236925270E-01 -0.9983198637050665347203E+00 -0.1790552765255420605839E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2978                             0                             0                             0                             0                             0                             0
 -0.2504796284291992969351E+00  0.1150000000000000049960E+00  0.3711498791369960970066E+00 -0.5409492179011441553849E-01 -0.9983198637050664236980E+00 -0.2076509495327851298474E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2979                             0                             0                             0                             0                             0                             0
 -0.2451042462855098635899E+00  0.1150000000000000049960E+00  0.3581725586627628743486E+00 -0.5293402547899165450085E-01 -0.9983198637050665347203E+00 -0.2356774657209998249940E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2980                             0                             0                             0                             0                             0                             0
 -0.2390570504397390994011E+00  0.1150000000000000049960E+00  0.3454943489198796235939E+00 -0.5162804068342997237950E-01 -0.9983198637050665347203E+00 -0.2630580063574130753046E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2981                             0                             0                             0                             0                             0                             0
 -0.2323546158353648471984E+00  0.1150000000000000049960E+00  0.3331499999999999461764E+00 -0.5018054701697612085542E-01 -0.9983198637050665347203E+00 -0.2897175232833384267428E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2982                             0                             0                             0                             0                             0                             0
 -0.2250153133797573312691E+00  0.1150000000000000049960E+00  0.3211733469054683376420E+00 -0.4859551195915581128792E-01 -0.9983198637050665347203E+00 -0.3155829446159619244838E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2983                             0                             0                             0                             0                             0                             0
 -0.2170592595907984145853E+00  0.1150000000000000049960E+00  0.3095972168099294652421E+00 -0.4687727998088805914101E-01 -0.9983198637050667567649E+00 -0.3405833750332949022566E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2984                             0                             0                             0                             0                             0                             0
 -0.2085082614589053862098E+00  0.1150000000000000049960E+00  0.2984533390813287612175E+00 -0.4503056063659249125264E-01 -0.9983198637050664236980E+00 -0.3646502900933214219581E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2985                             0                             0                             0                             0                             0                             0
 -0.1993857566755847798845E+00  0.1150000000000000049960E+00  0.2877722583139182832568E+00 -0.4306041565562785528032E-01 -0.9983198637050665347203E+00 -0.3877177240547338699095E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2986                             0                             0                             0                             0                             0                             0
 -0.1897167493923507253228E+00  0.1150000000000000049960E+00  0.2775832506076493233493E+00 -0.4097224506844401176187E-01 -0.9983198637050667567649E+00 -0.4097224506844399788408E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2987                             0                             0                             0                             0                             0                             0
 -0.1795277416860816266375E+00  0.1150000000000000049960E+00  0.2679142433244151022542E+00 -0.3877177240547335923537E-01 -0.9983198637050665347203E+00 -0.4306041565562788303589E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2988                             0                             0                             0                             0                             0                             0
 -0.1688466609186714817437E+00  0.1150000000000000049960E+00  0.2587917385410948289959E+00 -0.3646502900933219770696E-01 -0.9983198637050665347203E+00 -0.4503056063659244961928E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2989                             0                             0                             0                             0                             0                             0
 -0.1577027831900705556745E+00  0.1150000000000000049960E+00  0.2502407404092016340869E+00 -0.3405833750332950410344E-01 -0.9983198637050665347203E+00 -0.4687727998088804526322E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2990                             0                             0                             0                             0                             0                             0
 -0.1461266530945319330748E+00  0.1150000000000000049960E+00  0.2422846866202428561810E+00 -0.3155829446159624795953E-01 -0.9983198637050665347203E+00 -0.4859551195915577659346E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2991                             0                             0                             0                             0                             0                             0
