  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           551                             0                             0                             0                             0                             0                             0
 -0.2023805587630688462841E+00 -0.1500082858934205787271E+00  0.8178334102418141071666E+00 -0.1219036916787284881292E-01  0.9997027456190181737838E+00  0.2111433876177692264831E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           552                             0                             0                             0                             0                             0                             0
 -0.2204487044610397017408E+00 -0.1500082858934205787271E+00  0.8067612363178704448785E+00 -0.1327870180013441918365E-01  0.9997027456190181737838E+00  0.2044740766696862346863E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           553                             0                             0                             0                             0                             0                             0
 -0.2379126155832842759441E+00 -0.1500082858934205787271E+00  0.7947586227408409698114E+00 -0.1433063843375305922156E-01  0.9997027456190183958284E+00  0.1972443164902705145525E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           554                             0                             0                             0                             0                             0                             0
 -0.2547244247633182467894E+00 -0.1500082858934205787271E+00  0.7818584678402484833271E+00 -0.1534329578353524868584E-01  0.9997027456190183958284E+00  0.1894739233496392852296E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           555                             0                             0                             0                             0                             0                             0
 -0.2708380520007537262117E+00 -0.1500082858934205787271E+00  0.7680961300439967942566E+00 -0.1631389822607418743639E-01  0.9997027456190183958284E+00  0.1811841953552776121605E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           556                             0                             0                             0                             0                             0                             0
 -0.2862093309633771953671E+00 -0.1500082858934205787271E+00  0.7535093309633772440392E+00 -0.1723978540754060942430E-01  0.9997027456190183958284E+00  0.1723978540754061289375E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           557                             0                             0                             0                             0                             0                             0
 -0.3007961300439966900733E+00 -0.1500082858934205787271E+00  0.7381380520007536638616E+00 -0.1811841953552775427716E-01  0.9997027456190182848061E+00  0.1631389822607418743639E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           558                             0                             0                             0                             0                             0                             0
 -0.3145584678402483236326E+00 -0.1500082858934205787271E+00  0.7220244247633184064838E+00 -0.1894739233496392158407E-01  0.9997027456190183958284E+00  0.1534329578353525909418E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           559                             0                             0                             0                             0                             0                             0
 -0.3274586227408408656281E+00 -0.1500082858934205787271E+00  0.7052126155832842968607E+00 -0.1972443164902704798580E-01  0.9997027456190183958284E+00  0.1433063843375306616046E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           560                             0                             0                             0                             0                             0                             0
 -0.3394612363178706182509E+00 -0.1500082858934205787271E+00  0.6877487044610396393907E+00 -0.2044740766696862693808E-01  0.9997027456190185068508E+00  0.1327870180013441744893E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           561                             0                             0                             0                             0                             0                             0
 -0.3505334102418141140056E+00 -0.1500082858934205787271E+00  0.6696805587630690892453E+00 -0.2111433876177691570941E-01  0.9997027456190183958284E+00  0.1219036916787286269070E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           562                             0                             0                             0                             0                             0                             0
 -0.3606447964535635097860E+00 -0.1500082858934205787271E+00  0.6510577020208287990499E+00 -0.2172339692167887456598E-01  0.9997027456190182848061E+00  0.1106862358106432131510E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           563                             0                             0                             0                             0                             0                             0
 -0.3697676803463460504240E+00 -0.1500082858934205787271E+00  0.6319311781901909563786E+00 -0.2227291276059330943360E-01  0.9997027456190185068508E+00  0.9916539666390696353138E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           564                             0                             0                             0                             0                             0                             0
 -0.3778770567295358651094E+00 -0.1500082858934205787271E+00  0.6123534117435061041590E+00 -0.2276138009380216167821E-01  0.9997027456190185068508E+00  0.8737275205781675629924E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           565                             0                             0                             0                             0                             0                             0
 -0.3849506983661418746401E+00 -0.1500082858934205787271E+00  0.5923780639777720402606E+00 -0.2318746006629801223453E-01  0.9997027456190183958284E+00  0.7534062481154198305522E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           566                             0                             0                             0                             0                             0                             0
 -0.3909692168961214076006E+00 -0.1500082858934205787271E+00  0.5720598859327441498834E+00 -0.2354998482249273661360E-01  0.9997027456190182848061E+00  0.6310199414952121117761E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           567                             0                             0                             0                             0                             0                             0
 -0.3959161159785256622889E+00 -0.1500082858934205787271E+00  0.5514545683221452332390E+00 -0.2384796070722838140510E-01  0.9997027456190185068508E+00  0.5069040530770263161542E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           568                             0                             0                             0                             0                             0                             0
 -0.3997778365068245798319E+00 -0.1500082858934205787271E+00  0.5306185888892873681044E+00 -0.2408057098931693645882E-01  0.9997027456190182848061E+00  0.3813987758838231420522E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           569                             0                             0                             0                             0                             0                             0
 -0.4025437937734750448726E+00 -0.1500082858934205787271E+00  0.5096090576055055665350E+00 -0.2424717810014374169691E-01  0.9997027456190183958284E+00  0.2548481111566283131842E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           570                             0                             0                             0                             0                             0                             0
 -0.4042064064818684521185E+00 -0.1500082858934205787271E+00  0.4884835601356928291850E+00 -0.2434732538119874223348E-01  0.9997027456190183958284E+00  0.1275989254710239171123E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           571                             0                             0                             0                             0                             0                             0
 -0.4047611175261378591017E+00 -0.1500082858934205787271E+00  0.4673000000000000486722E+00 -0.2438073833574570803417E-01  0.9997027456190183958284E+00  0.2985779316372014862350E-17
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           572                             0                             0                             0                             0                             0                             0
 -0.4042064064818684521185E+00 -0.1500082858934205787271E+00  0.4461164398643069350925E+00 -0.2434732538119873876403E-01  0.9997027456190182848061E+00 -0.1275989254710254783634E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           573                             0                             0                             0                             0                             0                             0
 -0.4025437937734751003838E+00 -0.1500082858934205787271E+00  0.4249909423944948638763E+00 -0.2424717810014374516636E-01  0.9997027456190183958284E+00 -0.2548481111566255809947E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           574                             0                             0                             0                             0                             0                             0
 -0.3997778365068246353431E+00 -0.1500082858934205787271E+00  0.4039814111107126737288E+00 -0.2408057098931693992827E-01  0.9997027456190183958284E+00 -0.3813987758838224915309E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           575                             0                             0                             0                             0                             0                             0
 -0.3959161159785256622889E+00 -0.1500082858934205787271E+00  0.3831454316778548085942E+00 -0.2384796070722838140510E-01  0.9997027456190183958284E+00 -0.5069040530770257957371E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           576                             0                             0                             0                             0                             0                             0
 -0.3909692168961213520895E+00 -0.1500082858934205787271E+00  0.3625401140672556143940E+00 -0.2354998482249273314415E-01  0.9997027456190183958284E+00 -0.6310199414952135862911E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           577                             0                             0                             0                             0                             0                             0
 -0.3849506983661419301512E+00 -0.1500082858934205787271E+00  0.3422219360222280570838E+00 -0.2318746006629801570398E-01  0.9997027456190183958284E+00 -0.7534062481154193101351E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           578                             0                             0                             0                             0                             0                             0
 -0.3778770567295358651094E+00 -0.1500082858934205787271E+00  0.3222465882564939376742E+00 -0.2276138009380216167821E-01  0.9997027456190182848061E+00 -0.8737275205781670425753E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           579                             0                             0                             0                             0                             0                             0
 -0.3697676803463462724686E+00 -0.1500082858934205787271E+00  0.3026688218098093630104E+00 -0.2227291276059331984194E-01  0.9997027456190183958284E+00 -0.9916539666390672067009E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           580                             0                             0                             0                             0                             0                             0
 -0.3606447964535635652972E+00 -0.1500082858934205787271E+00  0.2835422979791712982944E+00 -0.2172339692167887803542E-01  0.9997027456190183958284E+00 -0.1106862358106431784566E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           581                             0                             0                             0                             0                             0                             0
 -0.3505334102418141695168E+00 -0.1500082858934205787271E+00  0.2649194412369310080990E+00 -0.2111433876177691917886E-01  0.9997027456190183958284E+00 -0.1219036916787285748653E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           582                             0                             0                             0                             0                             0                             0
 -0.3394612363178706737621E+00 -0.1500082858934205787271E+00  0.2468512955389604301981E+00 -0.2044740766696863040752E-01  0.9997027456190183958284E+00 -0.1327870180013441224476E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           583                             0                             0                             0                             0                             0                             0
 -0.3274586227408409766504E+00 -0.1500082858934205787271E+00  0.2293873844167157172169E+00 -0.1972443164902705492469E-01  0.9997027456190185068508E+00 -0.1433063843375305922156E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           584                             0                             0                             0                             0                             0                             0
 -0.3145584678402486011883E+00 -0.1500082858934205787271E+00  0.2125755752366819684163E+00 -0.1894739233496393893130E-01  0.9997027456190183958284E+00 -0.1534329578353523654277E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           585                             0                             0                             0                             0                             0                             0
 -0.3007961300439966345621E+00 -0.1500082858934205787271E+00  0.1964619479992461559270E+00 -0.1811841953552775080771E-01  0.9997027456190183958284E+00 -0.1631389822607419437528E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           586                             0                             0                             0                             0                             0                             0
 -0.2862093309633772508782E+00 -0.1500082858934205787271E+00  0.1810906690366227977940E+00 -0.1723978540754061636320E-01  0.9997027456190186178731E+00 -0.1723978540754060942430E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           587                             0                             0                             0                             0                             0                             0
 -0.2708380520007536707006E+00 -0.1500082858934205787271E+00  0.1665038699560031920655E+00 -0.1631389822607418396694E-01  0.9997027456190183958284E+00 -0.1811841953552776121605E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           588                             0                             0                             0                             0                             0                             0
 -0.2547244247633184688340E+00 -0.1500082858934205787271E+00  0.1527415321597517250396E+00 -0.1534329578353526082890E-01  0.9997027456190183958284E+00 -0.1894739233496391811462E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           589                             0                             0                             0                             0                             0                             0
 -0.2379126155832843592108E+00 -0.1500082858934205787271E+00  0.1398413772591591275329E+00 -0.1433063843375306616046E-01  0.9997027456190183958284E+00 -0.1972443164902704798580E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           590                             0                             0                             0                             0                             0                             0
 -0.2204487044610399515410E+00 -0.1500082858934205787271E+00  0.1278387636821295969547E+00 -0.1327870180013443653089E-01  0.9997027456190183958284E+00 -0.2044740766696861652973E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           591                             0                             0                             0                             0                             0                             0
 -0.2023805587630687630174E+00 -0.1500082858934205787271E+00  0.1167665897581857681331E+00 -0.1219036916787284534347E-01  0.9997027456190182848061E+00 -0.2111433876177692264831E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           592                             0                             0                             0                             0                             0                             0
 -0.1837577020208288058889E+00 -0.1500082858934205787271E+00  0.1066552035464364833750E+00 -0.1106862358106432304983E-01  0.9997027456190183958284E+00 -0.2172339692167887456598E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           593                             0                             0                             0                             0                             0                             0
 -0.1646311781901907134174E+00 -0.1500082858934205787271E+00  0.9753231965365377620358E-01 -0.9916539666390679005903E-02  0.9997027456190185068508E+00 -0.2227291276059331984194E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           594                             0                             0                             0                             0                             0                             0
 -0.1450534117435064995760E+00 -0.1500082858934205787271E+00  0.8942294327046423907390E-01 -0.8737275205781696446605E-02  0.9997027456190183958284E+00 -0.2276138009380215126987E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           595                             0                             0                             0                             0                             0                             0
 -0.1250780639777720193440E+00 -0.1500082858934205787271E+00  0.8234930163385811852095E-01 -0.7534062481154200040245E-02  0.9997027456190183958284E+00 -0.2318746006629801223453E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           596                             0                             0                             0                             0                             0                             0
 -0.1047598859327441289668E+00 -0.1500082858934205787271E+00  0.7633078310387858556041E-01 -0.6310199414952121985123E-02  0.9997027456190183958284E+00 -0.2354998482249273661360E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           597                             0                             0                             0                             0                             0                             0
 -0.8415456832214496252220E-01 -0.1500082858934205787271E+00  0.7138388402147427536093E-01 -0.5069040530770244079584E-02  0.9997027456190183958284E+00 -0.2384796070722838140510E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           598                             0                             0                             0                             0                             0                             0
 -0.6331858888928745821012E-01 -0.1500082858934205787271E+00  0.6752216349317541332908E-01 -0.3813987758838232721564E-02  0.9997027456190182848061E+00 -0.2408057098931693645882E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           599                             0                             0                             0                             0                             0                             0
 -0.4230905760550522642927E-01 -0.1500082858934205787271E+00  0.6475620622652489277726E-01 -0.2548481111566263182522E-02  0.9997027456190185068508E+00 -0.2424717810014374516636E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           600                             0                             0                             0                             0                             0                             0
 -0.2118356013569318990752E-01 -0.1500082858934205787271E+00  0.6309359351813154104249E-01 -0.1275989254710262156209E-02  0.9997027456190182848061E+00 -0.2434732538119873876403E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           601                             0                             0                             0                             0                             0                             0
  0.2618816711648417169247E-16 -0.1437667757714674865444E+00  0.3961477459921680654986E-01 -0.2806759479253668874850E-16  0.8887570259382635562417E+00  0.4583786086254166280973E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           602                             0                             0                             0                             0                             0                             0
  0.2238331524232901534321E-01 -0.1437667757714674865444E+00  0.4020090233661083312100E-01 -0.2398968280372134123657E-01  0.8887570259382634452194E+00  0.4577504166730486656611E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           603                             0                             0                             0                             0                             0                             0
  0.4470527937342385488284E-01 -0.1437667757714674865444E+00  0.4195767901340591299331E-01 -0.4791361155437996038886E-01  0.8887570259382634452194E+00  0.4558675626464213093136E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           604                             0                             0                             0                             0                             0                             0
  0.6690470944118209750684E-01 -0.1437667757714674865444E+00  0.4488028942684296751509E-01 -0.7170621242620242585808E-01  0.8887570259382637782863E+00  0.4527352073175458513354E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           605                             0                             0                             0                             0                             0                             0
  0.8892075835085139212666E-01 -0.1437667757714674865444E+00  0.4896072290492708978249E-01 -0.9530227155400239347216E-01  0.8887570259382635562417E+00  0.4483619362546513720247E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           606                             0                             0                             0                             0                             0                             0
  0.1106930816426870550773E+00 -0.1437667757714674865444E+00  0.5418779526312206273886E-01 -0.1186371137798524072471E+00  0.8887570259382636672640E+00  0.4427597362897390254055E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           607                             0                             0                             0                             0                             0                             0
  0.1321620028919219536068E+00 -0.1437667757714674865444E+00  0.6054717945942361678746E-01 -0.1416467799231966029350E+00  0.8887570259382635562417E+00  0.4359439626635083775419E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           608                             0                             0                             0                             0                             0                             0
  0.1532686772776983008537E+00 -0.1437667757714674865444E+00  0.6802144486378497445500E-01 -0.1642682020885183058478E+00  0.8887570259382636672640E+00  0.4279332969377103723652E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           609                             0                             0                             0                             0                             0                             0
  0.1739552528726314994945E+00 -0.1437667757714674865444E+00  0.7659010503426261218252E-01 -0.1864393765300579874911E+00  0.8887570259382635562417E+00  0.4187496957902848704336E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           610                             0                             0                             0                             0                             0                             0
  0.1941650292109222686321E+00 -0.1437667757714674865444E+00  0.8622967386892954611000E-01 -0.2080995335997710415921E+00  0.8887570259382634452194E+00  0.4084183308336326589938E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           611                             0                             0                             0                             0                             0                             0
  0.2138426127003915377944E+00 -0.1437667757714674865444E+00  0.9691372997964803337467E-01 -0.2291893043127082585375E+00  0.8887570259382635562417E+00  0.3969675196209756506960E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           612                             0                             0                             0                             0                             0                             0
  0.2329340684524668914079E+00 -0.1437667757714674865444E+00  0.1086129891112584400226E+00 -0.2496508830732776795802E+00  0.8887570259382635562417E+00  0.3844286480299113906156E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           613                             0                             0                             0                             0                             0                             0
  0.2513870681139626084288E+00 -0.1437667757714674865444E+00  0.1212953844076864462487E+00 -0.2694281861163633218226E+00  0.8887570259382635562417E+00  0.3708360842359049169836E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           614                             0                             0                             0                             0                             0                             0
  0.2691510332954587525478E+00 -0.1437667757714674865444E+00  0.1349261543049670719618E+00 -0.2884670052290276287543E+00  0.8887570259382635562417E+00  0.3562270845115079187515E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           615                             0                             0                             0                             0                             0                             0
  0.2861772742031510330385E+00 -0.1437667757714674865444E+00  0.1494679378102750089141E+00 -0.3067151563314547968453E+00  0.8887570259382634452194E+00  0.3406416911095059840697E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           616                             0                             0                             0                             0                             0                             0
  0.3024191230941908337115E+00 -0.1437667757714674865444E+00  0.1648808769058091039383E+00 -0.3241226225098865487695E+00  0.8887570259382635562417E+00  0.3241226225098866042806E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           617                             0                             0                             0                             0                             0                             0
  0.3178320621897250397581E+00 -0.1437667757714674865444E+00  0.1811227257968489601225E+00 -0.3406416911095060395809E+00  0.8887570259382635562417E+00  0.3067151563314547968453E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           618                             0                             0                             0                             0                             0                             0
  0.3323738456950329767103E+00 -0.1437667757714674865444E+00  0.1981489667045412961244E+00 -0.3562270845115079742627E+00  0.8887570259382635562417E+00  0.2884670052290275732432E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           619                             0                             0                             0                             0                             0                             0
  0.3460046155923135469124E+00 -0.1437667757714674865444E+00  0.2159129318860373847322E+00 -0.3708360842359049169836E+00  0.8887570259382635562417E+00  0.2694281861163633218226E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           620                             0                             0                             0                             0                             0                             0
  0.3586870108887415531385E+00 -0.1437667757714674865444E+00  0.2343659315475331017531E+00 -0.3844286480299113906156E+00  0.8887570259382635562417E+00  0.2496508830732776795802E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           621                             0                             0                             0                             0                             0                             0
  0.3703862700203519042752E+00 -0.1437667757714674865444E+00  0.2534573872996084276110E+00 -0.3969675196209755951848E+00  0.8887570259382634452194E+00  0.2291893043127083140487E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           622                             0                             0                             0                             0                             0                             0
  0.3810703261310705025622E+00 -0.1437667757714674865444E+00  0.2731349707890777800401E+00 -0.4084183308336327145049E+00  0.8887570259382635562417E+00  0.2080995335997710138365E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           623                             0                             0                             0                             0                             0                             0
  0.3907098949657373809785E+00 -0.1437667757714674865444E+00  0.2933447471273684659110E+00 -0.4187496957902848704336E+00  0.8887570259382635562417E+00  0.1864393765300580430022E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           624                             0                             0                             0                             0                             0                             0
  0.3992785551362150187060E+00 -0.1437667757714674865444E+00  0.3140313227223017200629E+00 -0.4279332969377103723652E+00  0.8887570259382636672640E+00  0.1642682020885182780923E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           625                             0                             0                             0                             0                             0                             0
  0.4067528205405763763736E+00 -0.1437667757714674865444E+00  0.3351379971080780673098E+00 -0.4359439626635083775419E+00  0.8887570259382634452194E+00  0.1416467799231965751794E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           626                             0                             0                             0                             0                             0                             0
  0.4131122047368779304222E+00 -0.1437667757714674865444E+00  0.3566069183573129519615E+00 -0.4427597362897390254055E+00  0.8887570259382636672640E+00  0.1186371137798523794915E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           627                             0                             0                             0                             0                             0                             0
  0.4183392770950729588897E+00 -0.1437667757714674865444E+00  0.3783792416491487120567E+00 -0.4483619362546514275358E+00  0.8887570259382635562417E+00  0.9530227155400225469428E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           628                             0                             0                             0                             0                             0                             0
  0.4224197105731570256459E+00 -0.1437667757714674865444E+00  0.4003952905588179511653E+00 -0.4527352073175458513354E+00  0.8887570259382637782863E+00  0.7170621242620241198029E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           629                             0                             0                             0                             0                             0                             0
  0.4253423209865940801677E+00 -0.1437667757714674865444E+00  0.4225947206265761590949E+00 -0.4558675626464213093136E+00  0.8887570259382634452194E+00  0.4791361155437993263329E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           630                             0                             0                             0                             0                             0                             0
  0.4270990976633891600400E+00 -0.1437667757714674865444E+00  0.4449166847576710992485E+00 -0.4577504166730486656611E+00  0.8887570259382634452194E+00  0.2398968280372121286703E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           631                             0                             0                             0                             0                             0                             0
  0.4276852254007831866112E+00 -0.1437667757714674865444E+00  0.4672999999999998821387E+00 -0.4583786086254166280973E+00  0.8887570259382635562417E+00  0.1017804970583161834557E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           632                             0                             0                             0                             0                             0                             0
  0.4270990976633891600400E+00 -0.1437667757714674865444E+00  0.4896833152423288870736E+00 -0.4577504166730486656611E+00  0.8887570259382634452194E+00 -0.2398968280372121286703E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           633                             0                             0                             0                             0                             0                             0
  0.4253423209865940801677E+00 -0.1437667757714674865444E+00  0.5120052793734237717160E+00 -0.4558675626464213093136E+00  0.8887570259382634452194E+00 -0.4791361155437993263329E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           634                             0                             0                             0                             0                             0                             0
  0.4224197105731570256459E+00 -0.1437667757714674865444E+00  0.5342047094411820351567E+00 -0.4527352073175458513354E+00  0.8887570259382637782863E+00 -0.7170621242620241198029E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           635                             0                             0                             0                             0                             0                             0
  0.4183392770950729033785E+00 -0.1437667757714674865444E+00  0.5562207583508513852877E+00 -0.4483619362546513720247E+00  0.8887570259382635562417E+00 -0.9530227155400236571658E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           636                             0                             0                             0                             0                             0                             0
  0.4131122047368779304222E+00 -0.1437667757714674865444E+00  0.5779930816426870343605E+00 -0.4427597362897390254055E+00  0.8887570259382636672640E+00 -0.1186371137798523794915E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           637                             0                             0                             0                             0                             0                             0
  0.4067528205405763763736E+00 -0.1437667757714674865444E+00  0.5994620028919219745234E+00 -0.4359439626635083775419E+00  0.8887570259382634452194E+00 -0.1416467799231965751794E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           638                             0                             0                             0                             0                             0                             0
  0.3992785551362150187060E+00 -0.1437667757714674865444E+00  0.6205686772776982662592E+00 -0.4279332969377103723652E+00  0.8887570259382636672640E+00 -0.1642682020885182780923E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           639                             0                             0                             0                             0                             0                             0
  0.3907098949657374364897E+00 -0.1437667757714674865444E+00  0.6412552528726315204111E+00 -0.4187496957902849259447E+00  0.8887570259382635562417E+00 -0.1864393765300579597355E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           640                             0                             0                             0                             0                             0                             0
  0.3810703261310705025622E+00 -0.1437667757714674865444E+00  0.6614650292109222062820E+00 -0.4084183308336327145049E+00  0.8887570259382635562417E+00 -0.2080995335997710138365E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           641                             0                             0                             0                             0                             0                             0
  0.3703862700203519597864E+00 -0.1437667757714674865444E+00  0.6811426127003914476887E+00 -0.3969675196209756506960E+00  0.8887570259382635562417E+00 -0.2291893043127082307819E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           642                             0                             0                             0                             0                             0                             0
  0.3586870108887416086496E+00 -0.1437667757714674865444E+00  0.7002340684524668290578E+00 -0.3844286480299114461268E+00  0.8887570259382635562417E+00 -0.2496508830732775685579E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           643                             0                             0                             0                             0                             0                             0
  0.3460046155923135469124E+00 -0.1437667757714674865444E+00  0.7186870681139625460787E+00 -0.3708360842359049169836E+00  0.8887570259382635562417E+00 -0.2694281861163633218226E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           644                             0                             0                             0                             0                             0                             0
  0.3323738456950330322215E+00 -0.1437667757714674865444E+00  0.7364510332954586901977E+00 -0.3562270845115080297738E+00  0.8887570259382635562417E+00 -0.2884670052290275177320E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           645                             0                             0                             0                             0                             0                             0
  0.3178320621897251507804E+00 -0.1437667757714674865444E+00  0.7534772742031509151772E+00 -0.3406416911095061506032E+00  0.8887570259382635562417E+00 -0.3067151563314546858230E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           646                             0                             0                             0                             0                             0                             0
  0.3024191230941908892227E+00 -0.1437667757714674865444E+00  0.7697191230941908823837E+00 -0.3241226225098866042806E+00  0.8887570259382635562417E+00 -0.3241226225098865487695E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           647                             0                             0                             0                             0                             0                             0
  0.2861772742031510330385E+00 -0.1437667757714674865444E+00  0.7851320621897249774079E+00 -0.3067151563314548523564E+00  0.8887570259382635562417E+00 -0.3406416911095059840697E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           648                             0                             0                             0                             0                             0                             0
  0.2691510332954586970367E+00 -0.1437667757714674865444E+00  0.7996738456950329698714E+00 -0.2884670052290275732432E+00  0.8887570259382635562417E+00 -0.3562270845115079742627E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           649                             0                             0                             0                             0                             0                             0
  0.2513870681139626084288E+00 -0.1437667757714674865444E+00  0.8133046155923135955845E+00 -0.2694281861163633218226E+00  0.8887570259382635562417E+00 -0.3708360842359049169836E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           650                             0                             0                             0                             0                             0                             0
  0.2329340684524669469191E+00 -0.1437667757714674865444E+00  0.8259870108887414907883E+00 -0.2496508830732777350914E+00  0.8887570259382635562417E+00 -0.3844286480299113906156E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           651                             0                             0                             0                             0                             0                             0
  0.2138426127003915377944E+00 -0.1437667757714674865444E+00  0.8376862700203520084585E+00 -0.2291893043127082585375E+00  0.8887570259382635562417E+00 -0.3969675196209756506960E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           652                             0                             0                             0                             0                             0                             0
  0.1941650292109222686321E+00 -0.1437667757714674865444E+00  0.8483703261310704402121E+00 -0.2080995335997710415921E+00  0.8887570259382634452194E+00 -0.4084183308336326589938E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           653                             0                             0                             0                             0                             0                             0
  0.1739552528726314162277E+00 -0.1437667757714674865444E+00  0.8580098949657374296507E+00 -0.1864393765300579042243E+00  0.8887570259382634452194E+00 -0.4187496957902849259447E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           654                             0                             0                             0                             0                             0                             0
  0.1532686772776981898314E+00 -0.1437667757714674865444E+00  0.8665785551362150673782E+00 -0.1642682020885181948255E+00  0.8887570259382635562417E+00 -0.4279332969377103723652E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           655                             0                             0                             0                             0                             0                             0
  0.1321620028919219536068E+00 -0.1437667757714674865444E+00  0.8740528205405764250457E+00 -0.1416467799231966029350E+00  0.8887570259382635562417E+00 -0.4359439626635083775419E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           656                             0                             0                             0                             0                             0                             0
  0.1106930816426869579328E+00 -0.1437667757714674865444E+00  0.8804122047368778680720E+00 -0.1186371137798523101026E+00  0.8887570259382635562417E+00 -0.4427597362897390254055E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           657                             0                             0                             0                             0                             0                             0
  0.8892075835085129498214E-01 -0.1437667757714674865444E+00  0.8856392770950729520507E+00 -0.9530227155400228244986E-01  0.8887570259382635562417E+00 -0.4483619362546514275358E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           658                             0                             0                             0                             0                             0                             0
  0.6690470944118209750684E-01 -0.1437667757714674865444E+00  0.8897197105731570188070E+00 -0.7170621242620242585808E-01  0.8887570259382637782863E+00 -0.4527352073175458513354E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           659                             0                             0                             0                             0                             0                             0
  0.4470527937342375773833E-01 -0.1437667757714674865444E+00  0.8926423209865941288399E+00 -0.4791361155437986324435E-01  0.8887570259382636672640E+00 -0.4558675626464213648248E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           660                             0                             0                             0                             0                             0                             0
  0.2238331524232892166815E-01 -0.1437667757714674865444E+00  0.8943990976633890976899E+00 -0.2398968280372124062261E-01  0.8887570259382634452194E+00 -0.4577504166730486656611E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           661                             0                             0                             0                             0                             0                             0
  0.2161185609292639096978E-15 -0.1437667757714674865444E+00  0.8949852254007831797722E+00 -0.2316285889091690433340E-15  0.8887570259382635562417E+00 -0.4583786086254166280973E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           662                             0                             0                             0                             0                             0                             0
 -0.2238331524232886962644E-01 -0.1437667757714674865444E+00  0.8943990976633890976899E+00  0.2398968280372118511146E-01  0.8887570259382634452194E+00 -0.4577504166730486656611E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           663                             0                             0                             0                             0                             0                             0
 -0.4470527937342370916607E-01 -0.1437667757714674865444E+00  0.8926423209865941288399E+00  0.4791361155437980079430E-01  0.8887570259382635562417E+00 -0.4558675626464213648248E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           664                             0                             0                             0                             0                             0                             0
 -0.6690470944118205587348E-01 -0.1437667757714674865444E+00  0.8897197105731570188070E+00  0.7170621242620238422472E-01  0.8887570259382636672640E+00 -0.4527352073175458513354E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           665                             0                             0                             0                             0                             0                             0
 -0.8892075835085125334878E-01 -0.1437667757714674865444E+00  0.8856392770950729520507E+00  0.9530227155400224081649E-01  0.8887570259382635562417E+00 -0.4483619362546514275358E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           666                             0                             0                             0                             0                             0                             0
 -0.1106930816426869162994E+00 -0.1437667757714674865444E+00  0.8804122047368779790943E+00  0.1186371137798522545914E+00  0.8887570259382636672640E+00 -0.4427597362897390809167E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           667                             0                             0                             0                             0                             0                             0
 -0.1321620028919218980956E+00 -0.1437667757714674865444E+00  0.8740528205405764250457E+00  0.1416467799231965474238E+00  0.8887570259382636672640E+00 -0.4359439626635083775419E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           668                             0                             0                             0                             0                             0                             0
 -0.1532686772776981343203E+00 -0.1437667757714674865444E+00  0.8665785551362150673782E+00  0.1642682020885181393144E+00  0.8887570259382635562417E+00 -0.4279332969377104278763E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           669                             0                             0                             0                             0                             0                             0
 -0.1739552528726315272500E+00 -0.1437667757714674865444E+00  0.8580098949657373186284E+00  0.1864393765300580152466E+00  0.8887570259382635562417E+00 -0.4187496957902848704336E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           670                             0                             0                             0                             0                             0                             0
 -0.1941650292109222408765E+00 -0.1437667757714674865444E+00  0.8483703261310704402121E+00  0.2080995335997709860809E+00  0.8887570259382635562417E+00 -0.4084183308336327145049E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           671                             0                             0                             0                             0                             0                             0
 -0.2138426127003915100389E+00 -0.1437667757714674865444E+00  0.8376862700203520084585E+00  0.2291893043127082030264E+00  0.8887570259382634452194E+00 -0.3969675196209756506960E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           672                             0                             0                             0                             0                             0                             0
 -0.2329340684524668914079E+00 -0.1437667757714674865444E+00  0.8259870108887414907883E+00  0.2496508830732776795802E+00  0.8887570259382633341971E+00 -0.3844286480299113906156E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           673                             0                             0                             0                             0                             0                             0
 -0.2513870681139625529177E+00 -0.1437667757714674865444E+00  0.8133046155923135955845E+00  0.2694281861163632663114E+00  0.8887570259382635562417E+00 -0.3708360842359049169836E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           674                             0                             0                             0                             0                             0                             0
 -0.2691510332954586970367E+00 -0.1437667757714674865444E+00  0.7996738456950329698714E+00  0.2884670052290275177320E+00  0.8887570259382635562417E+00 -0.3562270845115080297738E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           675                             0                             0                             0                             0                             0                             0
 -0.2861772742031510330385E+00 -0.1437667757714674865444E+00  0.7851320621897250884302E+00  0.3067151563314547968453E+00  0.8887570259382635562417E+00 -0.3406416911095060395809E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           676                             0                             0                             0                             0                             0                             0
 -0.3024191230941908337115E+00 -0.1437667757714674865444E+00  0.7697191230941908823837E+00  0.3241226225098865487695E+00  0.8887570259382635562417E+00 -0.3241226225098866042806E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           677                             0                             0                             0                             0                             0                             0
 -0.3178320621897249287358E+00 -0.1437667757714674865444E+00  0.7534772742031510261995E+00  0.3406416911095059285586E+00  0.8887570259382634452194E+00 -0.3067151563314548523564E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           678                             0                             0                             0                             0                             0                             0
 -0.3323738456950328656880E+00 -0.1437667757714674865444E+00  0.7364510332954588012200E+00  0.3562270845115078632404E+00  0.8887570259382635562417E+00 -0.2884670052290276842655E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           679                             0                             0                             0                             0                             0                             0
 -0.3460046155923134914012E+00 -0.1437667757714674865444E+00  0.7186870681139625460787E+00  0.3708360842359048614725E+00  0.8887570259382635562417E+00 -0.2694281861163633773337E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           680                             0                             0                             0                             0                             0                             0
 -0.3586870108887416086496E+00 -0.1437667757714674865444E+00  0.7002340684524668290578E+00  0.3844286480299114461268E+00  0.8887570259382635562417E+00 -0.2496508830732776240691E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           681                             0                             0                             0                             0                             0                             0
 -0.3703862700203518487641E+00 -0.1437667757714674865444E+00  0.6811426127003916697333E+00  0.3969675196209755396737E+00  0.8887570259382635562417E+00 -0.2291893043127084805821E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           682                             0                             0                             0                             0                             0                             0
 -0.3810703261310704470510E+00 -0.1437667757714674865444E+00  0.6614650292109223173043E+00  0.4084183308336326589938E+00  0.8887570259382634452194E+00 -0.2080995335997710693476E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           683                             0                             0                             0                             0                             0                             0
 -0.3907098949657372699562E+00 -0.1437667757714674865444E+00  0.6412552528726317424557E+00  0.4187496957902847594113E+00  0.8887570259382635562417E+00 -0.1864393765300582650468E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           684                             0                             0                             0                             0                             0                             0
 -0.3992785551362151297283E+00 -0.1437667757714674865444E+00  0.6205686772776980442146E+00  0.4279332969377104833875E+00  0.8887570259382636672640E+00 -0.1642682020885180282921E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           685                             0                             0                             0                             0                             0                             0
 -0.4067528205405763763736E+00 -0.1437667757714674865444E+00  0.5994620028919219745234E+00  0.4359439626635083775419E+00  0.8887570259382635562417E+00 -0.1416467799231966306905E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           686                             0                             0                             0                             0                             0                             0
 -0.4131122047368779304222E+00 -0.1437667757714674865444E+00  0.5779930816426870343605E+00  0.4427597362897390254055E+00  0.8887570259382635562417E+00 -0.1186371137798523378581E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           687                             0                             0                             0                             0                             0                             0
 -0.4183392770950729033785E+00 -0.1437667757714674865444E+00  0.5562207583508514963100E+00  0.4483619362546513720247E+00  0.8887570259382636672640E+00 -0.9530227155400251837225E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           688                             0                             0                             0                             0                             0                             0
 -0.4224197105731569701348E+00 -0.1437667757714674865444E+00  0.5342047094411821461790E+00  0.4527352073175457958243E+00  0.8887570259382635562417E+00 -0.7170621242620245361366E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           689                             0                             0                             0                             0                             0                             0
 -0.4253423209865940801677E+00 -0.1437667757714674865444E+00  0.5120052793734241047829E+00  0.4558675626464213093136E+00  0.8887570259382635562417E+00 -0.4791361155438029345577E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           690                             0                             0                             0                             0                             0                             0
 -0.4270990976633892155512E+00 -0.1437667757714674865444E+00  0.4896833152423287760513E+00  0.4577504166730487211723E+00  0.8887570259382636672640E+00 -0.2398968280372106715026E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           691                             0                             0                             0                             0                             0                             0
 -0.4276852254007831866112E+00 -0.1437667757714674865444E+00  0.4673000000000000486722E+00  0.4583786086254166280973E+00  0.8887570259382635562417E+00 -0.5613518958507337749700E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           692                             0                             0                             0                             0                             0                             0
 -0.4270990976633891600400E+00 -0.1437667757714674865444E+00  0.4449166847576709882262E+00  0.4577504166730486656611E+00  0.8887570259382634452194E+00  0.2398968280372135858380E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           693                             0                             0                             0                             0                             0                             0
 -0.4253423209865941356789E+00 -0.1437667757714674865444E+00  0.4225947206265763256283E+00  0.4558675626464213648248E+00  0.8887570259382635562417E+00  0.4791361155437977997762E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           694                             0                             0                             0                             0                             0                             0
 -0.4224197105731570256459E+00 -0.1437667757714674865444E+00  0.4003952905588179511653E+00  0.4527352073175458513354E+00  0.8887570259382636672640E+00  0.7170621242620234259135E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           695                             0                             0                             0                             0                             0                             0
 -0.4183392770950729033785E+00 -0.1437667757714674865444E+00  0.3783792416491486010344E+00  0.4483619362546513720247E+00  0.8887570259382635562417E+00  0.9530227155400240734995E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           696                             0                             0                             0                             0                             0                             0
 -0.4131122047368778749110E+00 -0.1437667757714674865444E+00  0.3566069183573127299169E+00  0.4427597362897389698944E+00  0.8887570259382636672640E+00  0.1186371137798526154139E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           697                             0                             0                             0                             0                             0                             0
 -0.4067528205405764318847E+00 -0.1437667757714674865444E+00  0.3351379971080781228210E+00  0.4359439626635083775419E+00  0.8887570259382636672640E+00  0.1416467799231965196682E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           698                             0                             0                             0                             0                             0                             0
 -0.3992785551362151297283E+00 -0.1437667757714674865444E+00  0.3140313227223020531298E+00  0.4279332969377104833875E+00  0.8887570259382634452194E+00  0.1642682020885179450254E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           699                             0                             0                             0                             0                             0                             0
 -0.3907098949657374920008E+00 -0.1437667757714674865444E+00  0.2933447471273686879556E+00  0.4187496957902849814559E+00  0.8887570259382635562417E+00  0.1864393765300578209576E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           700                             0                             0                             0                             0                             0                             0
 -0.3810703261310705025622E+00 -0.1437667757714674865444E+00  0.2731349707890777800401E+00  0.4084183308336327145049E+00  0.8887570259382635562417E+00  0.2080995335997709860809E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           701                             0                             0                             0                             0                             0                             0
 -0.3703862700203519042752E+00 -0.1437667757714674865444E+00  0.2534573872996083165887E+00  0.3969675196209755951848E+00  0.8887570259382635562417E+00  0.2291893043127083695598E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           702                             0                             0                             0                             0                             0                             0
 -0.3586870108887416086496E+00 -0.1437667757714674865444E+00  0.2343659315475332405310E+00  0.3844286480299115016379E+00  0.8887570259382636672640E+00  0.2496508830732775408023E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           703                             0                             0                             0                             0                             0                             0
 -0.3460046155923136024235E+00 -0.1437667757714674865444E+00  0.2159129318860374402433E+00  0.3708360842359049724948E+00  0.8887570259382635562417E+00  0.2694281861163632663114E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           704                             0                             0                             0                             0                             0                             0
 -0.3323738456950331432438E+00 -0.1437667757714674865444E+00  0.1981489667045415181690E+00  0.3562270845115081963073E+00  0.8887570259382635562417E+00  0.2884670052290272956874E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           705                             0                             0                             0                             0                             0                             0
 -0.3178320621897248732246E+00 -0.1437667757714674865444E+00  0.1811227257968488491002E+00  0.3406416911095058730474E+00  0.8887570259382635562417E+00  0.3067151563314549633787E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           706                             0                             0                             0                             0                             0                             0
 -0.3024191230941909447338E+00 -0.1437667757714674865444E+00  0.1648808769058091594495E+00  0.3241226225098866597918E+00  0.8887570259382635562417E+00  0.3241226225098865487695E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           707                             0                             0                             0                             0                             0                             0
 -0.2861772742031509775273E+00 -0.1437667757714674865444E+00  0.1494679378102748978918E+00  0.3067151563314547413341E+00  0.8887570259382635562417E+00  0.3406416911095060950920E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           708                             0                             0                             0                             0                             0                             0
 -0.2691510332954589190813E+00 -0.1437667757714674865444E+00  0.1349261543049671829841E+00  0.2884670052290277397766E+00  0.8887570259382635562417E+00  0.3562270845115078077292E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           709                             0                             0                             0                             0                             0                             0
 -0.2513870681139626084288E+00 -0.1437667757714674865444E+00  0.1212953844076865017598E+00  0.2694281861163633773337E+00  0.8887570259382635562417E+00  0.3708360842359048614725E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           710                             0                             0                             0                             0                             0                             0
 -0.2329340684524671967193E+00 -0.1437667757714674865444E+00  0.1086129891112586620672E+00  0.2496508830732779848915E+00  0.8887570259382635562417E+00  0.3844286480299112240822E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           711                             0                             0                             0                             0                             0                             0
 -0.2138426127003914267721E+00 -0.1437667757714674865444E+00  0.9691372997964797786352E-01  0.2291893043127081475152E+00  0.8887570259382634452194E+00  0.3969675196209757062071E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           712                             0                             0                             0                             0                             0                             0
 -0.1941650292109223241432E+00 -0.1437667757714674865444E+00  0.8622967386892954611000E-01  0.2080995335997710971032E+00  0.8887570259382635562417E+00  0.4084183308336326589938E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           713                             0                             0                             0                             0                             0                             0
 -0.1739552528726314717389E+00 -0.1437667757714674865444E+00  0.7659010503426255667137E-01  0.1864393765300579597355E+00  0.8887570259382635562417E+00  0.4187496957902849259447E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           714                             0                             0                             0                             0                             0                             0
 -0.1532686772776984396316E+00 -0.1437667757714674865444E+00  0.6802144486378502996615E-01  0.1642682020885184446257E+00  0.8887570259382636672640E+00  0.4279332969377103168540E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           715                             0                             0                             0                             0                             0                             0
 -0.1321620028919220091179E+00 -0.1437667757714674865444E+00  0.6054717945942361678746E-01  0.1416467799231966584461E+00  0.8887570259382635562417E+00  0.4359439626635083775419E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           716                             0                             0                             0                             0                             0                             0
 -0.1106930816426869995661E+00 -0.1437667757714674865444E+00  0.5418779526312206273886E-01  0.1186371137798523517359E+00  0.8887570259382635562417E+00  0.4427597362897390254055E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           717                             0                             0                             0                             0                             0                             0
 -0.8892075835085117008205E-01 -0.1437667757714674865444E+00  0.4896072290492703427134E-01  0.9530227155400214367198E-01  0.8887570259382634452194E+00  0.4483619362546514275358E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           718                             0                             0                             0                             0                             0                             0
 -0.6690470944118215301799E-01 -0.1437667757714674865444E+00  0.4488028942684302302624E-01  0.7170621242620248136923E-01  0.8887570259382635562417E+00  0.4527352073175457958243E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           719                             0                             0                             0                             0                             0                             0
 -0.4470527937342381324948E-01 -0.1437667757714674865444E+00  0.4195767901340585748216E-01  0.4791361155437991875550E-01  0.8887570259382636672640E+00  0.4558675626464213648248E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           720                             0                             0                             0                             0                             0                             0
 -0.2238331524232916105999E-01 -0.1437667757714674865444E+00  0.4020090233661083312100E-01  0.2398968280372149736168E-01  0.8887570259382635562417E+00  0.4577504166730486656611E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           721                             0                             0                             0                             0                             0                             0
  0.2745650093261849334703E-16 -0.1252491859380352179354E+00  0.1890131146817547458383E-01 -0.4615100205551978034002E-16  0.6572151062641362617711E+00  0.7537030609585050333621E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           722                             0                             0                             0                             0                             0                             0
  0.2346737414239502897417E-01 -0.1252491859380352179354E+00  0.1951582628690301524088E-01 -0.3944577041849724879929E-01  0.6572151062641362617711E+00  0.7526701371080900537791E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           723                             0                             0                             0                             0                             0                             0
  0.4687042584346279988639E-01 -0.1252491859380352179354E+00  0.2135768640068186341452E-01 -0.7878342272211906471835E-01  0.6572151062641362617711E+00  0.7495741967293216845292E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           724                             0                             0                             0                             0                             0                             0
  0.7014500896521709549791E-01 -0.1252491859380352179354E+00  0.2442184339896619205135E-01 -0.1179051351402282954428E+00  0.6572151062641363727934E+00  0.7444237255795818075654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
