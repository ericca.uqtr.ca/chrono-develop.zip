  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1074                             0                             0                             0                             0                             0                             0
 -0.1671375721579107243020E+00 -0.8350873084007630342551E-01  0.3189173847195619915240E-01  0.3578220770636371117490E+00  0.5517350488583738776782E-01  0.9321583800645024675546E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1075                             0                             0                             0                             0                             0                             0
 -0.1441210082009153070626E+00 -0.8350873084007630342551E-01  0.2374114569894347770429E-01  0.3085462941524256819115E+00  0.5517350488583738776782E-01  0.9496078499693532126713E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1076                             0                             0                             0                             0                             0                             0
 -0.1207094185781696638049E+00 -0.8350873084007630342551E-01  0.1680631691417200368477E-01  0.2584248072957324171561E+00  0.5517350488583738082893E-01  0.9644545107638702319264E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1077                             0                             0                             0                             0                             0                             0
 -0.9696697282951005636420E-01 -0.8350873084007630342551E-01  0.1110626000130687796030E-01  0.2075949960051297060737E+00  0.5517350488583738776782E-01  0.9766576687827945857379E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1078                             0                             0                             0                             0                             0                             0
 -0.7295874734841681363839E-01 -0.8350873084007630342551E-01  0.6656598420140102945197E-02  0.1561961812602289945140E+00  0.5517350488583738776782E-01  0.9861838760182273233568E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1079                             0                             0                             0                             0                             0                             0
 -0.4875054701214149438515E-01 -0.8350873084007630342551E-01  0.3469528383773401447598E-02  0.1043692436395566164320E+00  0.5517350488583740164561E-01  0.9930070217982951419344E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1080                             0                             0                             0                             0                             0                             0
 -0.2440872481511528052645E-01 -0.8350873084007630342551E-01  0.1553785429646070692655E-02  0.5225623717668622519872E-01  0.5517350488583738082893E-01  0.9971084043546853958873E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1081                             0                             0                             0                             0                             0                             0
  0.2857202088189609859734E-16 -0.6263164564168170744818E-01  0.6834881732585285085690E-03 -0.6123157930625321031066E-16  0.4984435425738802452611E-02  0.9999875776245855663049E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1082                             0                             0                             0                             0                             0                             0
  0.2442082134519948585782E-01 -0.6263164564168170744818E-01  0.1322969885659053268512E-02 -0.5233530610604784222284E-01  0.4984435425738802452611E-02  0.9986171294035931511601E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1083                             0                             0                             0                             0                             0                             0
  0.4877470691656213275245E-01 -0.6263164564168170744818E-01  0.3239662247936758721067E-02 -0.1045271647758412580931E+00  0.4984435425738801585249E-02  0.9945095410439311889306E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1084                             0                             0                             0                             0                             0                             0
  0.7299490440655488632249E-01 -0.6263164564168170744818E-01  0.6428311739554215531456E-02 -0.1564325217525784350592E+00  0.4984435425738803319973E-02  0.9876760711597784014870E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1085                             0                             0                             0                             0                             0                             0
  0.9701502793738286944958E-01 -0.6263164564168170744818E-01  0.1088017849389538715954E-01 -0.2079091080606830788113E+00  0.4984435425738801585249E-02  0.9781354498170985456440E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1086                             0                             0                             0                             0                             0                             0
  0.1207692400200662957710E+00 -0.6263164564168170744818E-01  0.1658306025363193159095E-01 -0.2588158299551780450187E+00  0.4984435425738802452611E-02  0.9659138271958316313004E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1087                             0                             0                             0                             0                             0                             0
  0.1441924320104217560612E+00 -0.6263164564168170744818E-01  0.2352132581626292795463E-01 -0.3090131556498338927241E+00  0.4984435425738802452611E-02  0.9510447019140677582527E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1088                             0                             0                             0                             0                             0                             0
  0.1672204025673297567156E+00 -0.6263164564168170744818E-01  0.3167595787815413732602E-01 -0.3583634977640946517319E+00  0.4984435425738802452611E-02  0.9335688292106641972268E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1089                             0                             0                             0                             0                             0                             0
  0.1897900336241482577293E+00 -0.6263164564168170744818E-01  0.4102460515964539977674E-01 -0.4067315904405250925890E+00  0.4984435425738802452611E-02  0.9135341092379678507029E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1090                             0                             0                             0                             0                             0                             0
  0.2118394633909465030186E+00 -0.6263164564168170744818E-01  0.5154164366835467525618E-01 -0.4539848600991244764735E+00  0.4984435425738801585249E-02  0.8909954557708276157157E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1091                             0                             0                             0                             0                             0                             0
  0.2333082559133706768151E+00 -0.6263164564168170744818E-01  0.6319824693275988281016E-01 -0.4999937888122926721302E+00  0.4984435425738802452611E-02  0.8660146456917544588450E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1092                             0                             0                             0                             0                             0                             0
  0.2541375667233944368739E+00 -0.6263164564168170744818E-01  0.7596246501355402580558E-01 -0.5446322693044687301978E+00  0.4984435425738803319973E-02  0.8386601496647799747208E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1093                             0                             0                             0                             0                             0                             0
  0.2742703041279150322218E+00 -0.6263164564168170744818E-01  0.8979931207620750477361E-01 -0.5877779506034060963415E+00  0.4984435425738802452611E-02  0.8090069444621266203654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1094                             0                             0                             0                             0                             0                             0
  0.2936512856931160486695E+00 -0.6263164564168170744818E-01  0.1046708622847090097707E+00 -0.6293125733956839162886E+00  0.4984435425738802452611E-02  0.7771363074580857066564E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1095                             0                             0                             0                             0                             0                             0
  0.3122273894956828499403E+00 -0.6263164564168170744818E-01  0.1205363537536457974042E+00 -0.6691222941672647639422E+00  0.4984435425738801585249E-02  0.7431355938533847904637E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1096                             0                             0                             0                             0                             0                             0
  0.3299476997263017241657E+00 -0.6263164564168170744818E-01  0.1373523002736982134842E+00 -0.7070979972406534752594E+00  0.4984435425738802452611E-02  0.7070979972406535862817E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1097                             0                             0                             0                             0                             0                             0
  0.3467636462463542512680E+00 -0.6263164564168170744818E-01  0.1550726105043171432207E+00 -0.7431355938533849014860E+00  0.4984435425738802452611E-02  0.6691222941672647639422E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1098                             0                             0                             0                             0                             0                             0
  0.3626291377152910389015E+00 -0.6263164564168170744818E-01  0.1736487143068840000026E+00 -0.7771363074580858176788E+00  0.4984435425738802452611E-02  0.6293125733956838052663E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1099                             0                             0                             0                             0                             0                             0
  0.3775006879237924883874E+00 -0.6263164564168170744818E-01  0.1930296958720849609392E+00 -0.8090069444621266203654E+00  0.4984435425738802452611E-02  0.5877779506034060963415E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1100                             0                             0                             0                             0                             0                             0
  0.3913375349864459673555E+00 -0.6263164564168170744818E-01  0.2131624332766055562871E+00 -0.8386601496647799747208E+00  0.4984435425738803319973E-02  0.5446322693044687301978E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1101                             0                             0                             0                             0                             0                             0
  0.4041017530672400548397E+00 -0.6263164564168170744818E-01  0.2339917440866292608348E+00 -0.8660146456917543478227E+00  0.4984435425738802452611E-02  0.4999937888122927831525E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1102                             0                             0                             0                             0                             0                             0
  0.4157583563316453734160E+00 -0.6263164564168170744818E-01  0.2554605366090535456536E+00 -0.8909954557708277267380E+00  0.4984435425738802452611E-02  0.4539848600991244209624E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1103                             0                             0                             0                             0                             0                             0
  0.4262753948403545933843E+00 -0.6263164564168170744818E-01  0.2775099663758516799206E+00 -0.9135341092379678507029E+00  0.4984435425738803319973E-02  0.4067315904405252036113E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1104                             0                             0                             0                             0                             0                             0
  0.4356240421218458558350E+00 -0.6263164564168170744818E-01  0.3000795974326702642010E+00 -0.9335688292106641972268E+00  0.4984435425738802452611E-02  0.3583634977640945962207E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1105                             0                             0                             0                             0                             0                             0
  0.4437786741837370652064E+00 -0.6263164564168170744818E-01  0.3231075679895782926110E+00 -0.9510447019140677582527E+00  0.4984435425738801585249E-02  0.3090131556498338372130E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1106                             0                             0                             0                             0                             0                             0
  0.4507169397463680615701E+00 -0.6263164564168170744818E-01  0.3465307599799337112678E+00 -0.9659138271958316313004E+00  0.4984435425738802452611E-02  0.2588158299551779895076E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1107                             0                             0                             0                             0                             0                             0
  0.4564198215061046060015E+00 -0.6263164564168170744818E-01  0.3702849720626172347338E+00 -0.9781354498170986566663E+00  0.4984435425738802452611E-02  0.2079091080606828012556E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1108                             0                             0                             0                             0                             0                             0
  0.4608716882604457776296E+00 -0.6263164564168170744818E-01  0.3943050955934451207163E+00 -0.9876760711597784014870E+00  0.4984435425738803319973E-02  0.1564325217525783795480E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1109                             0                             0                             0                             0                             0                             0
  0.4640603377520632344400E+00 -0.6263164564168170744818E-01  0.4185252930834378881642E+00 -0.9945095410439311889306E+00  0.4984435425738800717888E-02  0.1045271647758411887041E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1110                             0                             0                             0                             0                             0                             0
  0.4659770301143409398925E+00 -0.6263164564168170744818E-01  0.4428791786548006426116E+00 -0.9986171294035931511601E+00  0.4984435425738802452611E-02  0.5233530610604755772819E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1111                             0                             0                             0                             0                             0                             0
  0.4666165118267414646525E+00 -0.6263164564168170744818E-01  0.4672999999999998821387E+00 -0.9999875776245855663049E+00  0.4984435425738802452611E-02  0.2220418466035901797328E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1112                             0                             0                             0                             0                             0                             0
  0.4659770301143409398925E+00 -0.6263164564168170744818E-01  0.4917208213451993437104E+00 -0.9986171294035931511601E+00  0.4984435425738802452611E-02 -0.5233530610604755772819E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1113                             0                             0                             0                             0                             0                             0
  0.4640603377520632344400E+00 -0.6263164564168170744818E-01  0.5160747069165620981579E+00 -0.9945095410439311889306E+00  0.4984435425738800717888E-02 -0.1045271647758411887041E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1114                             0                             0                             0                             0                             0                             0
  0.4608716882604457776296E+00 -0.6263164564168170744818E-01  0.5402949044065548100946E+00 -0.9876760711597784014870E+00  0.4984435425738803319973E-02 -0.1564325217525783795480E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1115                             0                             0                             0                             0                             0                             0
  0.4564198215061046060015E+00 -0.6263164564168170744818E-01  0.5643150279373828626106E+00 -0.9781354498170985456440E+00  0.4984435425738801585249E-02 -0.2079091080606830233002E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1116                             0                             0                             0                             0                             0                             0
  0.4507169397463680615701E+00 -0.6263164564168170744818E-01  0.5880692400200662195431E+00 -0.9659138271958316313004E+00  0.4984435425738802452611E-02 -0.2588158299551779895076E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1117                             0                             0                             0                             0                             0                             0
  0.4437786741837370652064E+00 -0.6263164564168170744818E-01  0.6114924320104216937111E+00 -0.9510447019140677582527E+00  0.4984435425738801585249E-02 -0.3090131556498338372130E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1118                             0                             0                             0                             0                             0                             0
  0.4356240421218458558350E+00 -0.6263164564168170744818E-01  0.6345204025673296666099E+00 -0.9335688292106641972268E+00  0.4984435425738802452611E-02 -0.3583634977640945962207E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1119                             0                             0                             0                             0                             0                             0
  0.4262753948403546488954E+00 -0.6263164564168170744818E-01  0.6570900336241481953792E+00 -0.9135341092379679617252E+00  0.4984435425738802452611E-02 -0.4067315904405250370779E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1120                             0                             0                             0                             0                             0                             0
  0.4157583563316453734160E+00 -0.6263164564168170744818E-01  0.6791394633909464406685E+00 -0.8909954557708277267380E+00  0.4984435425738802452611E-02 -0.4539848600991244209624E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1121                             0                             0                             0                             0                             0                             0
  0.4041017530672401103509E+00 -0.6263164564168170744818E-01  0.7006082559133706144650E+00 -0.8660146456917544588450E+00  0.4984435425738802452611E-02 -0.4999937888122926166190E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1122                             0                             0                             0                             0                             0                             0
  0.3913375349864459673555E+00 -0.6263164564168170744818E-01  0.7214375667233943190126E+00 -0.8386601496647800857431E+00  0.4984435425738802452611E-02 -0.5446322693044685081531E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1123                             0                             0                             0                             0                             0                             0
  0.3775006879237924883874E+00 -0.6263164564168170744818E-01  0.7415703041279150253828E+00 -0.8090069444621266203654E+00  0.4984435425738802452611E-02 -0.5877779506034060963415E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1124                             0                             0                             0                             0                             0                             0
  0.3626291377152910944126E+00 -0.6263164564168170744818E-01  0.7609512856931159863194E+00 -0.7771363074580859287011E+00  0.4984435425738802452611E-02 -0.6293125733956836942440E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1125                             0                             0                             0                             0                             0                             0
  0.3467636462463543622903E+00 -0.6263164564168170744818E-01  0.7795273894956826765679E+00 -0.7431355938533851235306E+00  0.4984435425738802452611E-02 -0.6691222941672645418976E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1126                             0                             0                             0                             0                             0                             0
  0.3299476997263017796769E+00 -0.6263164564168170744818E-01  0.7972476997263017173267E+00 -0.7070979972406535862817E+00  0.4984435425738802452611E-02 -0.7070979972406534752594E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1127                             0                             0                             0                             0                             0                             0
  0.3122273894956829054514E+00 -0.6263164564168170744818E-01  0.8140636462463541889178E+00 -0.6691222941672648749645E+00  0.4984435425738802452611E-02 -0.7431355938533847904637E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1128                             0                             0                             0                             0                             0                             0
  0.2936512856931159931584E+00 -0.6263164564168170744818E-01  0.8299291377152910875736E+00 -0.6293125733956838052663E+00  0.4984435425738802452611E-02 -0.7771363074580858176788E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1129                             0                             0                             0                             0                             0                             0
  0.2742703041279150322218E+00 -0.6263164564168170744818E-01  0.8448006879237924815484E+00 -0.5877779506034060963415E+00  0.4984435425738802452611E-02 -0.8090069444621266203654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1130                             0                             0                             0                             0                             0                             0
  0.2541375667233944923851E+00 -0.6263164564168170744818E-01  0.8586375349864459050053E+00 -0.5446322693044688412201E+00  0.4984435425738802452611E-02 -0.8386601496647798636985E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1131                             0                             0                             0                             0                             0                             0
  0.2333082559133706768151E+00 -0.6263164564168170744818E-01  0.8714017530672401035119E+00 -0.4999937888122926721302E+00  0.4984435425738802452611E-02 -0.8660146456917544588450E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1132                             0                             0                             0                             0                             0                             0
  0.2118394633909465030186E+00 -0.6263164564168170744818E-01  0.8830583563316453110659E+00 -0.4539848600991244764735E+00  0.4984435425738801585249E-02 -0.8909954557708276157157E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1133                             0                             0                             0                             0                             0                             0
  0.1897900336241481467070E+00 -0.6263164564168170744818E-01  0.8935753948403546420565E+00 -0.4067315904405248705444E+00  0.4984435425738801585249E-02 -0.9135341092379679617252E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1134                             0                             0                             0                             0                             0                             0
  0.1672204025673296456933E+00 -0.6263164564168170744818E-01  0.9029240421218458489960E+00 -0.3583634977640944296873E+00  0.4984435425738801585249E-02 -0.9335688292106641972268E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1135                             0                             0                             0                             0                             0                             0
  0.1441924320104217560612E+00 -0.6263164564168170744818E-01  0.9110786741837371138786E+00 -0.3090131556498338927241E+00  0.4984435425738802452611E-02 -0.9510447019140677582527E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1136                             0                             0                             0                             0                             0                             0
  0.1207692400200661986265E+00 -0.6263164564168170744818E-01  0.9180169397463679992200E+00 -0.2588158299551778229741E+00  0.4984435425738802452611E-02 -0.9659138271958316313004E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1137                             0                             0                             0                             0                             0                             0
  0.9701502793738275842728E-01 -0.6263164564168170744818E-01  0.9237198215061046546737E+00 -0.2079091080606828567667E+00  0.4984435425738802452611E-02 -0.9781354498170986566663E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1138                             0                             0                             0                             0                             0                             0
  0.7299490440655488632249E-01 -0.6263164564168170744818E-01  0.9281716882604458263017E+00 -0.1564325217525784350592E+00  0.4984435425738803319973E-02 -0.9876760711597784014870E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1139                             0                             0                             0                             0                             0                             0
  0.4877470691656202866904E-01 -0.6263164564168170744818E-01  0.9313603377520632831121E+00 -0.1045271647758410360485E+00  0.4984435425738802452611E-02 -0.9945095410439312999529E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1140                             0                             0                             0                             0                             0                             0
  0.2442082134519938524386E-01 -0.6263164564168170744818E-01  0.9332770301143409330535E+00 -0.5233530610604762017823E-01  0.4984435425738802452611E-02 -0.9986171294035931511601E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1141                             0                             0                             0                             0                             0                             0
  0.2357913789220261381256E-15 -0.6263164564168170744818E-01  0.9339165118267414023023E+00 -0.5053152725134335697763E-15  0.4984435425738802452611E-02 -0.9999875776245855663049E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1142                             0                             0                             0                             0                             0                             0
 -0.2442082134519932626326E-01 -0.6263164564168170744818E-01  0.9332770301143409330535E+00  0.5233530610604749527814E-01  0.4984435425738802452611E-02 -0.9986171294035931511601E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1143                             0                             0                             0                             0                             0                             0
 -0.4877470691656196621899E-01 -0.6263164564168170744818E-01  0.9313603377520632831121E+00  0.1045271647758409111484E+00  0.4984435425738802452611E-02 -0.9945095410439312999529E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1144                             0                             0                             0                             0                             0                             0
 -0.7299490440655483081134E-01 -0.6263164564168170744818E-01  0.9281716882604458263017E+00  0.1564325217525783240369E+00  0.4984435425738802452611E-02 -0.9876760711597784014870E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1145                             0                             0                             0                             0                             0                             0
 -0.9701502793738271679391E-01 -0.6263164564168170744818E-01  0.9237198215061046546737E+00  0.2079091080606827457444E+00  0.4984435425738802452611E-02 -0.9781354498170986566663E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1146                             0                             0                             0                             0                             0                             0
 -0.1207692400200661431153E+00 -0.6263164564168170744818E-01  0.9180169397463681102423E+00  0.2588158299551777119518E+00  0.4984435425738802452611E-02 -0.9659138271958317423227E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1147                             0                             0                             0                             0                             0                             0
 -0.1441924320104217283056E+00 -0.6263164564168170744818E-01  0.9110786741837371138786E+00  0.3090131556498337817018E+00  0.4984435425738802452611E-02 -0.9510447019140678692750E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1148                             0                             0                             0                             0                             0                             0
 -0.1672204025673295901822E+00 -0.6263164564168170744818E-01  0.9029240421218458489960E+00  0.3583634977640943186650E+00  0.4984435425738802452611E-02 -0.9335688292106643082491E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1149                             0                             0                             0                             0                             0                             0
 -0.1897900336241482854849E+00 -0.6263164564168170744818E-01  0.8935753948403546420565E+00  0.4067315904405251481002E+00  0.4984435425738803319973E-02 -0.9135341092379678507029E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1150                             0                             0                             0                             0                             0                             0
 -0.2118394633909464475074E+00 -0.6263164564168170744818E-01  0.8830583563316454220882E+00  0.4539848600991243654512E+00  0.4984435425738802452611E-02 -0.8909954557708277267380E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1151                             0                             0                             0                             0                             0                             0
 -0.2333082559133706213039E+00 -0.6263164564168170744818E-01  0.8714017530672401035119E+00  0.4999937888122925611079E+00  0.4984435425738802452611E-02 -0.8660146456917544588450E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1152                             0                             0                             0                             0                             0                             0
 -0.2541375667233944368739E+00 -0.6263164564168170744818E-01  0.8586375349864459050053E+00  0.5446322693044687301978E+00  0.4984435425738801585249E-02 -0.8386601496647798636985E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1153                             0                             0                             0                             0                             0                             0
 -0.2742703041279149767107E+00 -0.6263164564168170744818E-01  0.8448006879237924815484E+00  0.5877779506034059853192E+00  0.4984435425738801585249E-02 -0.8090069444621266203654E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1154                             0                             0                             0                             0                             0                             0
 -0.2936512856931159376472E+00 -0.6263164564168170744818E-01  0.8299291377152910875736E+00  0.6293125733956836942440E+00  0.4984435425738802452611E-02 -0.7771363074580859287011E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1155                             0                             0                             0                             0                             0                             0
 -0.3122273894956828499403E+00 -0.6263164564168170744818E-01  0.8140636462463541889178E+00  0.6691222941672647639422E+00  0.4984435425738802452611E-02 -0.7431355938533849014860E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1156                             0                             0                             0                             0                             0                             0
 -0.3299476997263017241657E+00 -0.6263164564168170744818E-01  0.7972476997263018283491E+00  0.7070979972406534752594E+00  0.4984435425738802452611E-02 -0.7070979972406535862817E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1157                             0                             0                             0                             0                             0                             0
 -0.3467636462463541402457E+00 -0.6263164564168170744818E-01  0.7795273894956828986125E+00  0.7431355938533846794414E+00  0.4984435425738801585249E-02 -0.6691222941672648749645E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1158                             0                             0                             0                             0                             0                             0
 -0.3626291377152909278792E+00 -0.6263164564168170744818E-01  0.7609512856931162083640E+00  0.7771363074580855956341E+00  0.4984435425738802452611E-02 -0.6293125733956841383332E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1159                             0                             0                             0                             0                             0                             0
 -0.3775006879237924328763E+00 -0.6263164564168170744818E-01  0.7415703041279150253828E+00  0.8090069444621265093431E+00  0.4984435425738802452611E-02 -0.5877779506034062073638E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1160                             0                             0                             0                             0                             0                             0
 -0.3913375349864459673555E+00 -0.6263164564168170744818E-01  0.7214375667233943190126E+00  0.8386601496647800857431E+00  0.4984435425738802452611E-02 -0.5446322693044686191755E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1161                             0                             0                             0                             0                             0                             0
 -0.4041017530672399993286E+00 -0.6263164564168170744818E-01  0.7006082559133708365096E+00  0.8660146456917542368004E+00  0.4984435425738802452611E-02 -0.4999937888122931162194E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1162                             0                             0                             0                             0                             0                             0
 -0.4157583563316453179048E+00 -0.6263164564168170744818E-01  0.6791394633909465516908E+00  0.8909954557708276157157E+00  0.4984435425738801585249E-02 -0.4539848600991245319847E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1163                             0                             0                             0                             0                             0                             0
 -0.4262753948403544823620E+00 -0.6263164564168170744818E-01  0.6570900336241485284461E+00  0.9135341092379676286583E+00  0.4984435425738802452611E-02 -0.4067315904405257032117E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1164                             0                             0                             0                             0                             0                             0
 -0.4356240421218459668573E+00 -0.6263164564168170744818E-01  0.6345204025673294445653E+00  0.9335688292106644192714E+00  0.4984435425738802452611E-02 -0.3583634977640940966204E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1165                             0                             0                             0                             0                             0                             0
 -0.4437786741837370652064E+00 -0.6263164564168170744818E-01  0.6114924320104218047334E+00  0.9510447019140677582527E+00  0.4984435425738802452611E-02 -0.3090131556498339482353E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1166                             0                             0                             0                             0                             0                             0
 -0.4507169397463680615701E+00 -0.6263164564168170744818E-01  0.5880692400200662195431E+00  0.9659138271958316313004E+00  0.4984435425738802452611E-02 -0.2588158299551778784853E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1167                             0                             0                             0                             0                             0                             0
 -0.4564198215061046060015E+00 -0.6263164564168170744818E-01  0.5643150279373829736329E+00  0.9781354498170985456440E+00  0.4984435425738802452611E-02 -0.2079091080606833563671E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1168                             0                             0                             0                             0                             0                             0
 -0.4608716882604457221184E+00 -0.6263164564168170744818E-01  0.5402949044065549211169E+00  0.9876760711597782904647E+00  0.4984435425738801585249E-02 -0.1564325217525784905703E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1169                             0                             0                             0                             0                             0                             0
 -0.4640603377520632344400E+00 -0.6263164564168170744818E-01  0.5160747069165624312248E+00  0.9945095410439311889306E+00  0.4984435425738801585249E-02 -0.1045271647758419797380E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1170                             0                             0                             0                             0                             0                             0
 -0.4659770301143409954037E+00 -0.6263164564168170744818E-01  0.4917208213451991771770E+00  0.9986171294035932621824E+00  0.4984435425738802452611E-02 -0.5233530610604723853907E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1171                             0                             0                             0                             0                             0                             0
 -0.4666165118267414646525E+00 -0.6263164564168170744818E-01  0.4673000000000000486722E+00  0.9999875776245855663049E+00  0.4984435425738802452611E-02 -0.1224631586125064206213E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1172                             0                             0                             0                             0                             0                             0
 -0.4659770301143409398925E+00 -0.6263164564168170744818E-01  0.4428791786548004760782E+00  0.9986171294035931511601E+00  0.4984435425738802452611E-02  0.5233530610604787691731E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1173                             0                             0                             0                             0                             0                             0
 -0.4640603377520632899511E+00 -0.6263164564168170744818E-01  0.4185252930834380546976E+00  0.9945095410439312999529E+00  0.4984435425738802452611E-02  0.1045271647758408556372E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1174                             0                             0                             0                             0                             0                             0
 -0.4608716882604457776296E+00 -0.6263164564168170744818E-01  0.3943050955934451762275E+00  0.9876760711597784014870E+00  0.4984435425738802452611E-02  0.1564325217525782407701E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1175                             0                             0                             0                             0                             0                             0
 -0.4564198215061046060015E+00 -0.6263164564168170744818E-01  0.3702849720626171237114E+00  0.9781354498170985456440E+00  0.4984435425738802452611E-02  0.2079091080606831343225E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1176                             0                             0                             0                             0                             0                             0
 -0.4507169397463680060589E+00 -0.6263164564168170744818E-01  0.3465307599799334892232E+00  0.9659138271958315202781E+00  0.4984435425738803319973E-02  0.2588158299551784891079E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1177                             0                             0                             0                             0                             0                             0
 -0.4437786741837371207176E+00 -0.6263164564168170744818E-01  0.3231075679895782926110E+00  0.9510447019140678692750E+00  0.4984435425738802452611E-02  0.3090131556498337261907E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1178                             0                             0                             0                             0                             0                             0
 -0.4356240421218459668573E+00 -0.6263164564168170744818E-01  0.3000795974326706527791E+00  0.9335688292106644192714E+00  0.4984435425738802452611E-02  0.3583634977640938745758E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1179                             0                             0                             0                             0                             0                             0
 -0.4262753948403547044066E+00 -0.6263164564168170744818E-01  0.2775099663758519019652E+00  0.9135341092379680727475E+00  0.4984435425738803319973E-02  0.4067315904405247040110E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1180                             0                             0                             0                             0                             0                             0
 -0.4157583563316453734160E+00 -0.6263164564168170744818E-01  0.2554605366090535456536E+00  0.8909954557708277267380E+00  0.4984435425738802452611E-02  0.4539848600991243654512E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1181                             0                             0                             0                             0                             0                             0
 -0.4041017530672400548397E+00 -0.6263164564168170744818E-01  0.2339917440866292053236E+00  0.8660146456917543478227E+00  0.4984435425738802452611E-02  0.4999937888122928941748E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1182                             0                             0                             0                             0                             0                             0
 -0.3913375349864460228666E+00 -0.6263164564168170744818E-01  0.2131624332766057228206E+00  0.8386601496647801967654E+00  0.4984435425738802452611E-02  0.5446322693044683971308E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1183                             0                             0                             0                             0                             0                             0
 -0.3775006879237925438986E+00 -0.6263164564168170744818E-01  0.1930296958720850164504E+00  0.8090069444621267313877E+00  0.4984435425738803319973E-02  0.5877779506034059853192E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1184                             0                             0                             0                             0                             0                             0
 -0.3626291377152912609461E+00 -0.6263164564168170744818E-01  0.1736487143068842220472E+00  0.7771363074580862617680E+00  0.4984435425738802452611E-02  0.6293125733956832501548E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1185                             0                             0                             0                             0                             0                             0
 -0.3467636462463540847345E+00 -0.6263164564168170744818E-01  0.1550726105043169766873E+00  0.7431355938533845684191E+00  0.4984435425738802452611E-02  0.6691222941672650970091E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1186                             0                             0                             0                             0                             0                             0
 -0.3299476997263018351880E+00 -0.6263164564168170744818E-01  0.1373523002736982689953E+00  0.7070979972406536973040E+00  0.4984435425738802452611E-02  0.7070979972406534752594E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1187                             0                             0                             0                             0                             0                             0
 -0.3122273894956827944291E+00 -0.6263164564168170744818E-01  0.1205363537536456863819E+00  0.6691222941672646529199E+00  0.4984435425738802452611E-02  0.7431355938533850125083E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1188                             0                             0                             0                             0                             0                             0
 -0.2936512856931162152030E+00 -0.6263164564168170744818E-01  0.1046708622847091207930E+00  0.6293125733956842493555E+00  0.4984435425738802452611E-02  0.7771363074580854846118E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1189                             0                             0                             0                             0                             0                             0
 -0.2742703041279150322218E+00 -0.6263164564168170744818E-01  0.8979931207620756028476E-01  0.5877779506034062073638E+00  0.4984435425738802452611E-02  0.8090069444621265093431E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1190                             0                             0                             0                             0                             0                             0
 -0.2541375667233947699408E+00 -0.6263164564168170744818E-01  0.7596246501355424785018E-01  0.5446322693044693963316E+00  0.4984435425738802452611E-02  0.8386601496647795306316E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1191                             0                             0                             0                             0                             0                             0
 -0.2333082559133705380372E+00 -0.6263164564168170744818E-01  0.6319824693275982729901E-01  0.4999937888122923945744E+00  0.4984435425738802452611E-02  0.8660146456917545698673E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1192                             0                             0                             0                             0                             0                             0
 -0.2118394633909465585297E+00 -0.6263164564168170744818E-01  0.5154164366835467525618E-01  0.4539848600991245874958E+00  0.4984435425738801585249E-02  0.8909954557708276157157E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1193                             0                             0                             0                             0                             0                             0
 -0.1897900336241482022182E+00 -0.6263164564168170744818E-01  0.4102460515964534426558E-01  0.4067315904405249815667E+00  0.4984435425738802452611E-02  0.9135341092379679617252E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1194                             0                             0                             0                             0                             0                             0
 -0.1672204025673298954935E+00 -0.6263164564168170744818E-01  0.3167595787815419283717E-01  0.3583634977640949847988E+00  0.4984435425738803319973E-02  0.9335688292106640862045E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1195                             0                             0                             0                             0                             0                             0
 -0.1441924320104218115723E+00 -0.6263164564168170744818E-01  0.2352132581626292795463E-01  0.3090131556498340037464E+00  0.4984435425738802452611E-02  0.9510447019140677582527E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1196                             0                             0                             0                             0                             0                             0
 -0.1207692400200662541376E+00 -0.6263164564168170744818E-01  0.1658306025363193159095E-01  0.2588158299551779339964E+00  0.4984435425738802452611E-02  0.9659138271958316313004E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1197                             0                             0                             0                             0                             0                             0
 -0.9701502793738261964940E-01 -0.6263164564168170744818E-01  0.1088017849389538715954E-01  0.2079091080606825514554E+00  0.4984435425738801585249E-02  0.9781354498170986566663E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1198                             0                             0                             0                             0                             0                             0
 -0.7299490440655494183364E-01 -0.6263164564168170744818E-01  0.6428311739554271042607E-02  0.1564325217525785460815E+00  0.4984435425738801585249E-02  0.9876760711597782904647E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1199                             0                             0                             0                             0                             0                             0
 -0.4877470691656208418019E-01 -0.6263164564168170744818E-01  0.3239662247936703209916E-02  0.1045271647758411609486E+00  0.4984435425738802452611E-02  0.9945095410439312999529E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1200                             0                             0                             0                             0                             0                             0
 -0.2442082134519964545238E-01 -0.6263164564168170744818E-01  0.1322969885659053268512E-02  0.5233530610604818222864E-01  0.4984435425738802452611E-02  0.9986171294035931511601E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1201                             0                             0                             0                             0                             0                             0
  0.2858577616120178179651E-16 -0.4175440864445545408046E-01  0.4588474145474363830033E-03 -0.6122590952006831116488E-16  0.1449217005109632895599E-01  0.9998949829893186702634E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1202                             0                             0                             0                             0                             0                             0
  0.2443257813411777237822E-01 -0.4175440864445545408046E-01  0.1098636989300516564327E-02 -0.5233046007726818021899E-01  0.1449217005109632895599E-01  0.9985246616660558016676E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1203                             0                             0                             0                             0                             0                             0
  0.4879818826985748286829E-01 -0.4175440864445545408046E-01  0.3016252094806437522578E-02 -0.1045174860009099732094E+00  0.1449217005109632722126E-01  0.9944174536517645934808E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1204                             0                             0                             0                             0                             0                             0
  0.7303004596347008325896E-01 -0.4175440864445545408046E-01  0.6206436681352844875192E-02 -0.1564180367603448529312E+00  0.1449217005109633069071E-01  0.9875846165181236813169E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1205                             0                             0                             0                             0                             0                             0
  0.9706173337735307660168E-01 -0.4175440864445545408046E-01  0.1066044667473514673262E-01 -0.2078898565535040598995E+00  0.1449217005109632722126E-01  0.9780448785967713609679E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1206                             0                             0                             0                             0                             0                             0
  0.1208273813267270180294E+00 -0.4175440864445545408046E-01  0.1636607394315570118692E-01 -0.2587918647000966854144E+00  0.1449217005109632895599E-01  0.9658243876462515586923E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1207                             0                             0                             0                             0                             0                             0
  0.1442618498224927658935E+00 -0.4175440864445545408046E-01  0.2330767975886527398899E-01 -0.3089845423339484531411E+00  0.1449217005109632722126E-01  0.9509566391828232490013E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1208                             0                             0                             0                             0                             0                             0
  0.1673009066154133306359E+00 -0.4175440864445545408046E-01  0.3146623766282796719196E-01 -0.3583303148145151606485E+00  0.1449217005109633069071E-01  0.9334823846715804007701E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1209                             0                             0                             0                             0                             0                             0
  0.1898814032522443961959E+00 -0.4175440864445545408046E-01  0.4081938561492348682691E-01 -0.4066939288094098547965E+00  0.1449217005109632722126E-01  0.9134495198295177198489E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1210                             0                             0                             0                             0                             0                             0
  0.2119414481612556244716E+00 -0.4175440864445545408046E-01  0.5134148728674448047826E-01 -0.4539428230143864317903E+00  0.1449217005109632722126E-01  0.8909129533466999539826E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1211                             0                             0                             0                             0                             0                             0
  0.2334205762927262228779E+00 -0.4175440864445545408046E-01  0.6300370232899066280652E-01 -0.4999474914946592241094E+00  0.1449217005109632722126E-01  0.8659344563853591525415E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1212                             0                             0                             0                             0                             0                             0
  0.2542599148494438798807E+00 -0.4175440864445545408046E-01  0.7577406542086212448694E-01 -0.5445818386516694253885E+00  0.1449217005109633069071E-01  0.8385824932694320166249E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1213                             0                             0                             0                             0                             0                             0
  0.2744023446529491594426E+00 -0.4175440864445545408046E-01  0.8961757388478092112294E-01 -0.5877235248423547941954E+00  0.1449217005109633069071E-01  0.8089320338286077882728E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1214                             0                             0                             0                             0                             0                             0
  0.2937926567032338454055E+00 -0.4175440864445545408046E-01  0.1044962836262980365731E+00 -0.6292543017036086316907E+00  0.1449217005109632722126E-01  0.7770643479112354645721E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1215                             0                             0                             0                             0                             0                             0
  0.3123777035027721082905E+00 -0.4175440864445545408046E-01  0.1203694131362183505907E+00 -0.6690603362628230188491E+00  0.1449217005109632722126E-01  0.7430667826293192446130E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1216                             0                             0                             0                             0                             0                             0
  0.3301065447301171906780E+00 -0.4175440864445545408046E-01  0.1371934552698827469719E+00 -0.7070325229461547067444E+00  0.1449217005109632895599E-01  0.7070325229461548177667E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1217                             0                             0                             0                             0                             0                             0
  0.3469305868637816980815E+00 -0.4175440864445545408046E-01  0.1549222964972278848705E+00 -0.7430667826293193556353E+00  0.1449217005109633069071E-01  0.6690603362628230188491E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1218                             0                             0                             0                             0                             0                             0
  0.3628037163737020120990E+00 -0.4175440864445545408046E-01  0.1735073432967662032667E+00 -0.7770643479112355755944E+00  0.1449217005109632895599E-01  0.6292543017036085206684E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1219                             0                             0                             0                             0                             0                             0
  0.3776824261152190720381E+00 -0.4175440864445545408046E-01  0.1928976553470508337185E+00 -0.8089320338286077882728E+00  0.1449217005109633069071E-01  0.5877235248423547941954E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1220                             0                             0                             0                             0                             0                             0
  0.3915259345791378686741E+00 -0.4175440864445545408046E-01  0.2130400851505561132804E+00 -0.8385824932694320166249E+00  0.1449217005109633069071E-01  0.5445818386516694253885E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1221                             0                             0                             0                             0                             0                             0
  0.4042962976710092748434E+00 -0.4175440864445545408046E-01  0.2338794237072737147720E+00 -0.8659344563853590415192E+00  0.1449217005109632722126E-01  0.4999474914946593351317E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1222                             0                             0                             0                             0                             0                             0
  0.4159585127132555681939E+00 -0.4175440864445545408046E-01  0.2553585518387443964450E+00 -0.8909129533467000650049E+00  0.1449217005109633069071E-01  0.4539428230143863762791E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1223                             0                             0                             0                             0                             0                             0
  0.4264806143850765063341E+00 -0.4175440864445545408046E-01  0.2774185967477555414540E+00 -0.9134495198295177198489E+00  0.1449217005109632722126E-01  0.4066939288094099658188E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1224                             0                             0                             0                             0                             0                             0
  0.4358337623371720259691E+00 -0.4175440864445545408046E-01  0.2999990933845866902807E+00 -0.9334823846715804007701E+00  0.1449217005109632895599E-01  0.3583303148145151051374E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1225                             0                             0                             0                             0                             0                             0
  0.4439923202411347191720E+00 -0.4175440864445545408046E-01  0.3230381501775072550231E+00 -0.9509566391828232490013E+00  0.1449217005109632722126E-01  0.3089845423339483976299E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1226                             0                             0                             0                             0                             0                             0
  0.4509339260568442919741E+00 -0.4175440864445545408046E-01  0.3464726186732730028872E+00 -0.9658243876462515586923E+00  0.1449217005109632895599E-01  0.2587918647000966299032E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1227                             0                             0                             0                             0                             0                             0
  0.4566395533252649019396E+00 -0.4175440864445545408046E-01  0.3702382666226470275816E+00 -0.9780448785967714719902E+00  0.1449217005109632895599E-01  0.2078898565535037823437E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1228                             0                             0                             0                             0                             0                             0
  0.4610935633186471482858E+00 -0.4175440864445545408046E-01  0.3942699540365299237799E+00 -0.9875846165181236813169E+00  0.1449217005109633069071E-01  0.1564180367603447974201E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1229                             0                             0                             0                             0                             0                             0
  0.4642837479051935556384E+00 -0.4175440864445545408046E-01  0.4185018117301425588650E+00 -0.9944174536517645934808E+00  0.1449217005109632722126E-01  0.1045174860009099038205E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1230                             0                             0                             0                             0                             0                             0
  0.4662013630106994765967E+00 -0.4175440864445545408046E-01  0.4428674218658823491523E+00 -0.9985246616660558016676E+00  0.1449217005109632895599E-01  0.5233046007726789572434E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1231                             0                             0                             0                             0                             0                             0
  0.4668411525854525567780E+00 -0.4175440864445545408046E-01  0.4672999999999998821387E+00 -0.9998949829893186702634E+00  0.1449217005109632895599E-01  0.2220212864643841644304E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1232                             0                             0                             0                             0                             0                             0
  0.4662013630106994765967E+00 -0.4175440864445545408046E-01  0.4917325781341176371697E+00 -0.9985246616660558016676E+00  0.1449217005109632895599E-01 -0.5233046007726789572434E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1233                             0                             0                             0                             0                             0                             0
  0.4642837479051935556384E+00 -0.4175440864445545408046E-01  0.5160981882698574274571E+00 -0.9944174536517645934808E+00  0.1449217005109632722126E-01 -0.1045174860009099038205E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1234                             0                             0                             0                             0                             0                             0
  0.4610935633186471482858E+00 -0.4175440864445545408046E-01  0.5403300459634701180534E+00 -0.9875846165181236813169E+00  0.1449217005109633069071E-01 -0.1564180367603447974201E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1235                             0                             0                             0                             0                             0                             0
  0.4566395533252648464284E+00 -0.4175440864445545408046E-01  0.5643617333773530697627E+00 -0.9780448785967713609679E+00  0.1449217005109632722126E-01 -0.2078898565535040043883E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1236                             0                             0                             0                             0                             0                             0
  0.4509339260568442919741E+00 -0.4175440864445545408046E-01  0.5881273813267269279237E+00 -0.9658243876462515586923E+00  0.1449217005109632895599E-01 -0.2587918647000966299032E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1237                             0                             0                             0                             0                             0                             0
  0.4439923202411347191720E+00 -0.4175440864445545408046E-01  0.6115618498224927312990E+00 -0.9509566391828232490013E+00  0.1449217005109632722126E-01 -0.3089845423339483976299E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1238                             0                             0                             0                             0                             0                             0
  0.4358337623371720259691E+00 -0.4175440864445545408046E-01  0.6346009066154132405302E+00 -0.9334823846715804007701E+00  0.1449217005109632895599E-01 -0.3583303148145151051374E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1239                             0                             0                             0                             0                             0                             0
  0.4264806143850765618453E+00 -0.4175440864445545408046E-01  0.6571814032522443893569E+00 -0.9134495198295178308712E+00  0.1449217005109633069071E-01 -0.4066939288094097992854E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1240                             0                             0                             0                             0                             0                             0
  0.4159585127132555681939E+00 -0.4175440864445545408046E-01  0.6792414481612556453882E+00 -0.8909129533467000650049E+00  0.1449217005109633069071E-01 -0.4539428230143863762791E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1241                             0                             0                             0                             0                             0                             0
  0.4042962976710093303545E+00 -0.4175440864445545408046E-01  0.7007205762927262160389E+00 -0.8659344563853591525415E+00  0.1449217005109632722126E-01 -0.4999474914946591685982E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1242                             0                             0                             0                             0                             0                             0
  0.3915259345791379241852E+00 -0.4175440864445545408046E-01  0.7215599148494438175305E+00 -0.8385824932694321276472E+00  0.1449217005109633069071E-01 -0.5445818386516692033439E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1243                             0                             0                             0                             0                             0                             0
  0.3776824261152190720381E+00 -0.4175440864445545408046E-01  0.7417023446529491526036E+00 -0.8089320338286077882728E+00  0.1449217005109633069071E-01 -0.5877235248423547941954E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1244                             0                             0                             0                             0                             0                             0
  0.3628037163737020120990E+00 -0.4175440864445545408046E-01  0.7610926567032336720331E+00 -0.7770643479112356866167E+00  0.1449217005109632722126E-01 -0.6292543017036084096461E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1245                             0                             0                             0                             0                             0                             0
  0.3469305868637818091038E+00 -0.4175440864445545408046E-01  0.7796777035027719904292E+00 -0.7430667826293195776799E+00  0.1449217005109633069071E-01 -0.6690603362628227968045E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1246                             0                             0                             0                             0                             0                             0
  0.3301065447301172461891E+00 -0.4175440864445545408046E-01  0.7974065447301171838390E+00 -0.7070325229461548177667E+00  0.1449217005109632895599E-01 -0.7070325229461547067444E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1247                             0                             0                             0                             0                             0                             0
  0.3123777035027721638016E+00 -0.4175440864445545408046E-01  0.8142305868637815802202E+00 -0.6690603362628231298714E+00  0.1449217005109633069071E-01 -0.7430667826293192446130E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
