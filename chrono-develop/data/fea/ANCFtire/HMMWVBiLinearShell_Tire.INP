                          1248                             0                             0                             0                             0                             0                             0
  0.2937926567032337898944E+00 -0.4175440864445545408046E-01  0.8301037163737019497489E+00 -0.6292543017036085206684E+00  0.1449217005109632895599E-01 -0.7770643479112355755944E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1249                             0                             0                             0                             0                             0                             0
  0.2744023446529491594426E+00 -0.4175440864445545408046E-01  0.8449824261152190096880E+00 -0.5877235248423547941954E+00  0.1449217005109633069071E-01 -0.8089320338286077882728E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1250                             0                             0                             0                             0                             0                             0
  0.2542599148494439353918E+00 -0.4175440864445545408046E-01  0.8588259345791378063240E+00 -0.5445818386516695364108E+00  0.1449217005109632722126E-01 -0.8385824932694319056026E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1251                             0                             0                             0                             0                             0                             0
  0.2334205762927262228779E+00 -0.4175440864445545408046E-01  0.8715962976710093235155E+00 -0.4999474914946592241094E+00  0.1449217005109632722126E-01 -0.8659344563853591525415E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1252                             0                             0                             0                             0                             0                             0
  0.2119414481612556244716E+00 -0.4175440864445545408046E-01  0.8832585127132555058438E+00 -0.4539428230143864317903E+00  0.1449217005109632722126E-01 -0.8909129533466999539826E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1253                             0                             0                             0                             0                             0                             0
  0.1898814032522442851736E+00 -0.4175440864445545408046E-01  0.8937806143850766105174E+00 -0.4066939288094096327519E+00  0.1449217005109632722126E-01 -0.9134495198295178308712E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1254                             0                             0                             0                             0                             0                             0
  0.1673009066154132473692E+00 -0.4175440864445545408046E-01  0.9031337623371720191301E+00 -0.3583303148145149386039E+00  0.1449217005109632722126E-01 -0.9334823846715804007701E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1255                             0                             0                             0                             0                             0                             0
  0.1442618498224927658935E+00 -0.4175440864445545408046E-01  0.9112923202411347123331E+00 -0.3089845423339484531411E+00  0.1449217005109632722126E-01 -0.9509566391828232490013E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1256                             0                             0                             0                             0                             0                             0
  0.1208273813267269070071E+00 -0.4175440864445545408046E-01  0.9182339260568442851351E+00 -0.2587918647000964633698E+00  0.1449217005109632722126E-01 -0.9658243876462515586923E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1257                             0                             0                             0                             0                             0                             0
  0.9706173337735297945716E-01 -0.4175440864445545408046E-01  0.9239395533252648951006E+00 -0.2078898565535038378549E+00  0.1449217005109632895599E-01 -0.9780448785967714719902E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1258                             0                             0                             0                             0                             0                             0
  0.7303004596347008325896E-01 -0.4175440864445545408046E-01  0.9283935633186470859357E+00 -0.1564180367603448529312E+00  0.1449217005109633069071E-01 -0.9875846165181236813169E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1259                             0                             0                             0                             0                             0                             0
  0.4879818826985737878488E-01 -0.4175440864445545408046E-01  0.9315837479051936043106E+00 -0.1045174860009097511648E+00  0.1449217005109632895599E-01 -0.9944174536517647045031E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1260                             0                             0                             0                             0                             0                             0
  0.2443257813411766829481E-01 -0.4175440864445545408046E-01  0.9335013630106994142466E+00 -0.5233046007726795817439E-01  0.1449217005109632895599E-01 -0.9985246616660558016676E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1261                             0                             0                             0                             0                             0                             0
  0.2359048947383679241454E-15 -0.4175440864445545408046E-01  0.9341411525854526054502E+00 -0.5052684824488366523516E-15  0.1449217005109632895599E-01 -0.9998949829893186702634E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1262                             0                             0                             0                             0                             0                             0
 -0.2443257813411760931421E-01 -0.4175440864445545408046E-01  0.9335013630106994142466E+00  0.5233046007726783327429E-01  0.1449217005109632722126E-01 -0.9985246616660558016676E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1263                             0                             0                             0                             0                             0                             0
 -0.4879818826985731633483E-01 -0.4175440864445545408046E-01  0.9315837479051936043106E+00  0.1045174860009096262647E+00  0.1449217005109632895599E-01 -0.9944174536517647045031E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1264                             0                             0                             0                             0                             0                             0
 -0.7303004596347004162560E-01 -0.4175440864445545408046E-01  0.9283935633186470859357E+00  0.1564180367603447419089E+00  0.1449217005109633069071E-01 -0.9875846165181236813169E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1265                             0                             0                             0                             0                             0                             0
 -0.9706173337735292394601E-01 -0.4175440864445545408046E-01  0.9239395533252648951006E+00  0.2078898565535037268326E+00  0.1449217005109632895599E-01 -0.9780448785967714719902E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1266                             0                             0                             0                             0                             0                             0
 -0.1208273813267268514959E+00 -0.4175440864445545408046E-01  0.9182339260568443961574E+00  0.2587918647000963523475E+00  0.1449217005109633069071E-01 -0.9658243876462516697146E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1267                             0                             0                             0                             0                             0                             0
 -0.1442618498224927381379E+00 -0.4175440864445545408046E-01  0.9112923202411347123331E+00  0.3089845423339483421188E+00  0.1449217005109633069071E-01 -0.9509566391828233600236E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1268                             0                             0                             0                             0                             0                             0
 -0.1673009066154131918580E+00 -0.4175440864445545408046E-01  0.9031337623371720191301E+00  0.3583303148145148275816E+00  0.1449217005109632722126E-01 -0.9334823846715805117924E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1269                             0                             0                             0                             0                             0                             0
 -0.1898814032522444239515E+00 -0.4175440864445545408046E-01  0.8937806143850764994951E+00  0.4066939288094099103077E+00  0.1449217005109632722126E-01 -0.9134495198295177198489E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1270                             0                             0                             0                             0                             0                             0
 -0.2119414481612555689605E+00 -0.4175440864445545408046E-01  0.8832585127132555058438E+00  0.4539428230143863207680E+00  0.1449217005109632895599E-01 -0.8909129533467000650049E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1271                             0                             0                             0                             0                             0                             0
 -0.2334205762927261673667E+00 -0.4175440864445545408046E-01  0.8715962976710093235155E+00  0.4999474914946591130871E+00  0.1449217005109632548654E-01 -0.8659344563853591525415E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1272                             0                             0                             0                             0                             0                             0
 -0.2542599148494438798807E+00 -0.4175440864445545408046E-01  0.8588259345791378063240E+00  0.5445818386516694253885E+00  0.1449217005109632722126E-01 -0.8385824932694319056026E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1273                             0                             0                             0                             0                             0                             0
 -0.2744023446529491039314E+00 -0.4175440864445545408046E-01  0.8449824261152190096880E+00  0.5877235248423546831731E+00  0.1449217005109632895599E-01 -0.8089320338286077882728E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1274                             0                             0                             0                             0                             0                             0
 -0.2937926567032337343832E+00 -0.4175440864445545408046E-01  0.8301037163737019497489E+00  0.6292543017036084096461E+00  0.1449217005109632722126E-01 -0.7770643479112356866167E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1275                             0                             0                             0                             0                             0                             0
 -0.3123777035027721082905E+00 -0.4175440864445545408046E-01  0.8142305868637816912425E+00  0.6690603362628230188491E+00  0.1449217005109633069071E-01 -0.7430667826293193556353E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1276                             0                             0                             0                             0                             0                             0
 -0.3301065447301171906780E+00 -0.4175440864445545408046E-01  0.7974065447301172948613E+00  0.7070325229461547067444E+00  0.1449217005109632895599E-01 -0.7070325229461548177667E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1277                             0                             0                             0                             0                             0                             0
 -0.3469305868637815870592E+00 -0.4175440864445545408046E-01  0.7796777035027722124738E+00  0.7430667826293191335907E+00  0.1449217005109632722126E-01 -0.6690603362628231298714E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1278                             0                             0                             0                             0                             0                             0
 -0.3628037163737019010767E+00 -0.4175440864445545408046E-01  0.7610926567032338940777E+00  0.7770643479112353535498E+00  0.1449217005109633069071E-01 -0.6292543017036088537353E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1279                             0                             0                             0                             0                             0                             0
 -0.3776824261152190165269E+00 -0.4175440864445545408046E-01  0.7417023446529491526036E+00  0.8089320338286076772505E+00  0.1449217005109633069071E-01 -0.5877235248423549052177E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1280                             0                             0                             0                             0                             0                             0
 -0.3915259345791379241852E+00 -0.4175440864445545408046E-01  0.7215599148494438175305E+00  0.8385824932694321276472E+00  0.1449217005109633069071E-01 -0.5445818386516693143662E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1281                             0                             0                             0                             0                             0                             0
 -0.4042962976710092193322E+00 -0.4175440864445545408046E-01  0.7007205762927264380835E+00  0.8659344563853589304969E+00  0.1449217005109632895599E-01 -0.4999474914946596681986E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1282                             0                             0                             0                             0                             0                             0
 -0.4159585127132555126828E+00 -0.4175440864445545408046E-01  0.6792414481612556453882E+00  0.8909129533466999539826E+00  0.1449217005109632722126E-01 -0.4539428230143864873014E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1283                             0                             0                             0                             0                             0                             0
 -0.4264806143850763953118E+00 -0.4175440864445545408046E-01  0.6571814032522447224238E+00  0.9134495198295174978043E+00  0.1449217005109632895599E-01 -0.4066939288094104654192E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1284                             0                             0                             0                             0                             0                             0
 -0.4358337623371721369914E+00 -0.4175440864445545408046E-01  0.6346009066154130184856E+00  0.9334823846715806228147E+00  0.1449217005109632895599E-01 -0.3583303148145146055370E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1285                             0                             0                             0                             0                             0                             0
 -0.4439923202411347191720E+00 -0.4175440864445545408046E-01  0.6115618498224928423213E+00  0.9509566391828232490013E+00  0.1449217005109632895599E-01 -0.3089845423339485086522E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1286                             0                             0                             0                             0                             0                             0
 -0.4509339260568442919741E+00 -0.4175440864445545408046E-01  0.5881273813267269279237E+00  0.9658243876462515586923E+00  0.1449217005109632722126E-01 -0.2587918647000965188809E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1287                             0                             0                             0                             0                             0                             0
 -0.4566395533252648464284E+00 -0.4175440864445545408046E-01  0.5643617333773531807850E+00  0.9780448785967713609679E+00  0.1449217005109632895599E-01 -0.2078898565535043374553E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1288                             0                             0                             0                             0                             0                             0
 -0.4610935633186470927747E+00 -0.4175440864445545408046E-01  0.5403300459634701180534E+00  0.9875846165181235702946E+00  0.1449217005109632722126E-01 -0.1564180367603449084424E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1289                             0                             0                             0                             0                             0                             0
 -0.4642837479051935556384E+00 -0.4175440864445545408046E-01  0.5160981882698577605240E+00  0.9944174536517645934808E+00  0.1449217005109632895599E-01 -0.1045174860009106948544E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1290                             0                             0                             0                             0                             0                             0
 -0.4662013630106995321079E+00 -0.4175440864445545408046E-01  0.4917325781341174706363E+00  0.9985246616660559126899E+00  0.1449217005109632895599E-01 -0.5233046007726757653522E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1291                             0                             0                             0                             0                             0                             0
 -0.4668411525854525567780E+00 -0.4175440864445545408046E-01  0.4673000000000000486722E+00  0.9998949829893186702634E+00  0.1449217005109632895599E-01 -0.1224518190401366223298E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1292                             0                             0                             0                             0                             0                             0
 -0.4662013630106994765967E+00 -0.4175440864445545408046E-01  0.4428674218658821826189E+00  0.9985246616660558016676E+00  0.1449217005109632895599E-01  0.5233046007726821491346E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1293                             0                             0                             0                             0                             0                             0
 -0.4642837479051936111496E+00 -0.4175440864445545408046E-01  0.4185018117301426698873E+00  0.9944174536517647045031E+00  0.1449217005109632895599E-01  0.1045174860009095707536E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1294                             0                             0                             0                             0                             0                             0
 -0.4610935633186471482858E+00 -0.4175440864445545408046E-01  0.3942699540365299792910E+00  0.9875846165181236813169E+00  0.1449217005109633069071E-01  0.1564180367603446586422E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1295                             0                             0                             0                             0                             0                             0
 -0.4566395533252648464284E+00 -0.4175440864445545408046E-01  0.3702382666226469165593E+00  0.9780448785967713609679E+00  0.1449217005109632722126E-01  0.2078898565535041154106E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1296                             0                             0                             0                             0                             0                             0
 -0.4509339260568442364630E+00 -0.4175440864445545408046E-01  0.3464726186732727808426E+00  0.9658243876462514476700E+00  0.1449217005109633069071E-01  0.2587918647000971295036E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1297                             0                             0                             0                             0                             0                             0
 -0.4439923202411347746832E+00 -0.4175440864445545408046E-01  0.3230381501775072550231E+00  0.9509566391828233600236E+00  0.1449217005109633069071E-01  0.3089845423339482866076E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1298                             0                             0                             0                             0                             0                             0
 -0.4358337623371721369914E+00 -0.4175440864445545408046E-01  0.2999990933845870233476E+00  0.9334823846715806228147E+00  0.1449217005109632722126E-01  0.3583303148145143834924E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1299                             0                             0                             0                             0                             0                             0
 -0.4264806143850766173564E+00 -0.4175440864445545408046E-01  0.2774185967477557634986E+00  0.9134495198295179418935E+00  0.1449217005109632895599E-01  0.4066939288094094662185E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1300                             0                             0                             0                             0                             0                             0
 -0.4159585127132555681939E+00 -0.4175440864445545408046E-01  0.2553585518387444519561E+00  0.8909129533467000650049E+00  0.1449217005109632895599E-01  0.4539428230143863207680E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1301                             0                             0                             0                             0                             0                             0
 -0.4042962976710092748434E+00 -0.4175440864445545408046E-01  0.2338794237072736592609E+00  0.8659344563853590415192E+00  0.1449217005109632895599E-01  0.4999474914946594461540E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1302                             0                             0                             0                             0                             0                             0
 -0.3915259345791379796964E+00 -0.4175440864445545408046E-01  0.2130400851505562243027E+00  0.8385824932694322386695E+00  0.1449217005109633069071E-01  0.5445818386516690923216E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1303                             0                             0                             0                             0                             0                             0
 -0.3776824261152191275492E+00 -0.4175440864445545408046E-01  0.1928976553470508892296E+00  0.8089320338286078992951E+00  0.1449217005109633242543E-01  0.5877235248423546831731E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1304                             0                             0                             0                             0                             0                             0
 -0.3628037163737021786325E+00 -0.4175440864445545408046E-01  0.1735073432967664253113E+00  0.7770643479112360196837E+00  0.1449217005109632895599E-01  0.6292543017036079655568E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1305                             0                             0                             0                             0                             0                             0
 -0.3469305868637815870592E+00 -0.4175440864445545408046E-01  0.1549222964972277183371E+00  0.7430667826293190225684E+00  0.1449217005109632722126E-01  0.6690603362628233519160E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1306                             0                             0                             0                             0                             0                             0
 -0.3301065447301173017003E+00 -0.4175440864445545408046E-01  0.1371934552698828024830E+00  0.7070325229461549287890E+00  0.1449217005109633069071E-01  0.7070325229461547067444E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1307                             0                             0                             0                             0                             0                             0
 -0.3123777035027720527793E+00 -0.4175440864445545408046E-01  0.1203694131362182395684E+00  0.6690603362628229078268E+00  0.1449217005109632895599E-01  0.7430667826293194666576E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1308                             0                             0                             0                             0                             0                             0
 -0.2937926567032340119390E+00 -0.4175440864445545408046E-01  0.1044962836262981475954E+00  0.6292543017036089647576E+00  0.1449217005109632895599E-01  0.7770643479112352425275E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1309                             0                             0                             0                             0                             0                             0
 -0.2744023446529492149537E+00 -0.4175440864445545408046E-01  0.8961757388478097663409E-01  0.5877235248423549052177E+00  0.1449217005109633069071E-01  0.8089320338286076772505E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1310                             0                             0                             0                             0                             0                             0
 -0.2542599148494442129476E+00 -0.4175440864445545408046E-01  0.7577406542086234653155E-01  0.5445818386516700915223E+00  0.1449217005109633069071E-01  0.8385824932694315725357E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1311                             0                             0                             0                             0                             0                             0
 -0.2334205762927260841000E+00 -0.4175440864445545408046E-01  0.6300370232899060729537E-01  0.4999474914946589465536E+00  0.1449217005109632722126E-01  0.8659344563853592635638E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1312                             0                             0                             0                             0                             0                             0
 -0.2119414481612556799828E+00 -0.4175440864445545408046E-01  0.5134148728674448047826E-01  0.4539428230143865428126E+00  0.1449217005109632895599E-01  0.8909129533466999539826E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1313                             0                             0                             0                             0                             0                             0
 -0.1898814032522443406847E+00 -0.4175440864445545408046E-01  0.4081938561492343131576E-01  0.4066939288094097437742E+00  0.1449217005109632895599E-01  0.9134495198295178308712E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1314                             0                             0                             0                             0                             0                             0
 -0.1673009066154134971693E+00 -0.4175440864445545408046E-01  0.3146623766282802270311E-01  0.3583303148145154937154E+00  0.1449217005109633069071E-01  0.9334823846715802897478E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1315                             0                             0                             0                             0                             0                             0
 -0.1442618498224928214047E+00 -0.4175440864445545408046E-01  0.2330767975886527398899E-01  0.3089845423339485641634E+00  0.1449217005109632895599E-01  0.9509566391828232490013E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1316                             0                             0                             0                             0                             0                             0
 -0.1208273813267269625182E+00 -0.4175440864445545408046E-01  0.1636607394315570118692E-01  0.2587918647000965743921E+00  0.1449217005109632895599E-01  0.9658243876462515586923E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1317                             0                             0                             0                             0                             0                             0
 -0.9706173337735282680150E-01 -0.4175440864445545408046E-01  0.1066044667473509122146E-01  0.2078898565535035325436E+00  0.1449217005109632722126E-01  0.9780448785967714719902E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1318                             0                             0                             0                             0                             0                             0
 -0.7303004596347013877011E-01 -0.4175440864445545408046E-01  0.6206436681352900386344E-02  0.1564180367603449639535E+00  0.1449217005109632722126E-01  0.9875846165181235702946E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1319                             0                             0                             0                             0                             0                             0
 -0.4879818826985743429603E-01 -0.4175440864445545408046E-01  0.3016252094806382011427E-02  0.1045174860009098760649E+00  0.1449217005109633069071E-01  0.9944174536517647045031E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1320                             0                             0                             0                             0                             0                             0
 -0.2443257813411793197278E-01 -0.4175440864445545408046E-01  0.1098636989300516564327E-02  0.5233046007726852022479E-01  0.1449217005109632895599E-01  0.9985246616660558016676E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1321                             0                             0                             0                             0                             0                             0
  0.2860448741097507908179E-16 -0.2087723167897392873016E-01  0.1532695159022767761314E-03 -0.6122728769178313627970E-16  0.1284572727460347139894E-01  0.9999174902414631471714E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1322                             0                             0                             0                             0                             0                             0
  0.2444857084565007707133E-01 -0.2087723167897392873016E-01  0.7934778745452009118821E-03 -0.5233163801583156499175E-01  0.1284572727460347139894E-01  0.9985471380727934942456E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1323                             0                             0                             0                             0                             0                             0
  0.4883012985801141875308E-01 -0.2087723167897392873016E-01  0.2712348183863177997210E-02 -0.1045198386493890185811E+00  0.1284572727460346966422E-01  0.9944398376068268596839E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1324                             0                             0                             0                             0                             0                             0
  0.7307784887857275701872E-01 -0.2087723167897392873016E-01  0.5904620953717465425825E-02 -0.1564215576702936150166E+00  0.1284572727460347139894E-01  0.9876068466686456215342E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1325                             0                             0                             0                             0                             0                             0
  0.9712526659493693481640E-01 -0.2087723167897392873016E-01  0.1036154638633807190118E-01 -0.2078945360743530978986E+00  0.1284572727460347139894E-01  0.9780668940114556342280E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1326                             0                             0                             0                             0                             0                             0
  0.1209064707066587890383E+00 -0.2087723167897392873016E-01  0.1607090835891122893031E-01 -0.2587976900056045970189E+00  0.1284572727460347139894E-01  0.9658461279823766787445E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1327                             0                             0                             0                             0                             0                             0
  0.1443562785862795294634E+00 -0.2087723167897392873016E-01  0.2301705790712299526390E-01 -0.3089914974573577666206E+00  0.1284572727460346966422E-01  0.9509780448516391704317E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1328                             0                             0                             0                             0                             0                             0
  0.1674104159403771718839E+00 -0.2087723167897392873016E-01  0.3118095611788268550768E-01 -0.3583383806923160497249E+00  0.1284572727460347139894E-01  0.9335033970016367588229E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1329                             0                             0                             0                             0                             0                             0
  0.1900056929809375017015E+00 -0.2087723167897392873016E-01  0.4054022631366022144661E-01 -0.4067030833335919526306E+00  0.1284572727460346966422E-01  0.9134700812274783032763E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1330                             0                             0                             0                             0                             0                             0
  0.2120801776241709180049E+00 -0.2087723167897392873016E-01  0.5106921538540387661698E-01 -0.4539530410930352477550E+00  0.1284572727460347139894E-01  0.8909330074552022082912E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1331                             0                             0                             0                             0                             0                             0
  0.2335733652420488026813E+00 -0.2087723167897392873016E-01  0.6273906410592888782674E-01 -0.4999587451207314625634E+00  0.1284572727460347139894E-01  0.8659539482374857266578E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1332                             0                             0                             0                             0                             0                             0
  0.2544263445012839297554E+00 -0.2087723167897392873016E-01  0.7551778623105381837988E-01 -0.5445940969797582464906E+00  0.1284572727460347313366E-01  0.8386013694393709139163E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1333                             0                             0                             0                             0                             0                             0
  0.2745819588351993134623E+00 -0.2087723167897392873016E-01  0.8937035617167160550522E-01 -0.5877367542732349070533E+00  0.1284572727460347139894E-01  0.8089502425780893402063E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1334                             0                             0                             0                             0                             0                             0
  0.2939849631059054391180E+00 -0.2087723167897392873016E-01  0.1042588049964554564042E+00 -0.6292684659763296828316E+00  0.1284572727460346966422E-01  0.7770818393313431160507E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1335                             0                             0                             0                             0                             0                             0
  0.3125821750273824473076E+00 -0.2087723167897392873016E-01  0.1201423245020599162025E+00 -0.6690753965540979786297E+00  0.1284572727460346966422E-01  0.7430835087772861280442E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1336                             0                             0                             0                             0                             0                             0
  0.3303226209344299335591E+00 -0.2087723167897392873016E-01  0.1369773790655700040908E+00 -0.7070484379767719707033E+00  0.1284572727460346966422E-01  0.7070484379767720817256E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1337                             0                             0                             0                             0                             0                             0
  0.3471576754979401324697E+00 -0.2087723167897392873016E-01  0.1547178249726175458534E+00 -0.7430835087772862390665E+00  0.1284572727460347139894E-01  0.6690753965540979786297E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1338                             0                             0                             0                             0                             0                             0
  0.3630411950035445922680E+00 -0.2087723167897392873016E-01  0.1733150368940946095542E+00 -0.7770818393313432270730E+00  0.1284572727460346966422E-01  0.6292684659763295718093E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1339                             0                             0                             0                             0                             0                             0
  0.3779296438283283876558E+00 -0.2087723167897392873016E-01  0.1927180411648006796987E+00 -0.8089502425780893402063E+00  0.1284572727460347139894E-01  0.5877367542732349070533E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1340                             0                             0                             0                             0                             0                             0
  0.3917822137689461747811E+00 -0.2087723167897392873016E-01  0.2128736554987160634056E+00 -0.8386013694393709139163E+00  0.1284572727460347313366E-01  0.5445940969797582464906E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1341                             0                             0                             0                             0                             0                             0
  0.4045609358940710498231E+00 -0.2087723167897392873016E-01  0.2337266347579511349686E+00 -0.8659539482374856156355E+00  0.1284572727460346966422E-01  0.4999587451207315735857E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1342                             0                             0                             0                             0                             0                             0
  0.4162307846145961720552E+00 -0.2087723167897392873016E-01  0.2552198223758290751562E+00 -0.8909330074552023193135E+00  0.1284572727460347313366E-01  0.4539530410930351922438E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1343                             0                             0                             0                             0                             0                             0
  0.4267597736863397717144E+00 -0.2087723167897392873016E-01  0.2772943070190624359483E+00 -0.9134700812274783032763E+00  0.1284572727460347139894E-01  0.4067030833335920636529E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1344                             0                             0                             0                             0                             0                             0
  0.4361190438821173076533E+00 -0.2087723167897392873016E-01  0.2998895840596228490327E+00 -0.9335033970016367588229E+00  0.1284572727460346966422E-01  0.3583383806923159942137E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1345                             0                             0                             0                             0                             0                             0
  0.4442829420928769978971E+00 -0.2087723167897392873016E-01  0.3229437214137205192088E+00 -0.9509780448516391704317E+00  0.1284572727460346966422E-01  0.3089914974573577111094E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1346                             0                             0                             0                             0                             0                             0
  0.4512290916410887642307E+00 -0.2087723167897392873016E-01  0.3463935292933412180005E+00 -0.9658461279823766787445E+00  0.1284572727460346966422E-01  0.2587976900056045415077E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1347                             0                             0                             0                             0                             0                             0
  0.4569384536136619212598E+00 -0.2087723167897392873016E-01  0.3701747334050631832447E+00 -0.9780668940114557452503E+00  0.1284572727460347139894E-01  0.2078945360743528203429E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1348                             0                             0                             0                             0                             0                             0
  0.4613953790462825277352E+00 -0.2087723167897392873016E-01  0.3942221511214272777757E+00 -0.9876068466686456215342E+00  0.1284572727460347139894E-01  0.1564215576702935595055E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1349                             0                             0                             0                             0                             0                             0
  0.4645876518161368151638E+00 -0.2087723167897392873016E-01  0.4184698701419886091024E+00 -0.9944398376068268596839E+00  0.1284572727460346966422E-01  0.1045198386493889491922E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1350                             0                             0                             0                             0                             0                             0
  0.4665065221254547922491E+00 -0.2087723167897392873016E-01  0.4428514291543500513981E+00 -0.9985471380727934942456E+00  0.1284572727460347139894E-01  0.5233163801583128049710E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1351                             0                             0                             0                             0                             0                             0
  0.4671467304840977163849E+00 -0.2087723167897392873016E-01  0.4672999999999998821387E+00 -0.9999174902414631471714E+00  0.1284572727460347139894E-01  0.2220262840782945328691E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1352                             0                             0                             0                             0                             0                             0
  0.4665065221254547922491E+00 -0.2087723167897392873016E-01  0.4917485708456499349239E+00 -0.9985471380727934942456E+00  0.1284572727460347139894E-01 -0.5233163801583128049710E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1353                             0                             0                             0                             0                             0                             0
  0.4645876518161368151638E+00 -0.2087723167897392873016E-01  0.5161301298580114327308E+00 -0.9944398376068268596839E+00  0.1284572727460346966422E-01 -0.1045198386493889491922E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1354                             0                             0                             0                             0                             0                             0
  0.4613953790462825277352E+00 -0.2087723167897392873016E-01  0.5403778488785727640575E+00 -0.9876068466686456215342E+00  0.1284572727460347139894E-01 -0.1564215576702935595055E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1355                             0                             0                             0                             0                             0                             0
  0.4569384536136619212598E+00 -0.2087723167897392873016E-01  0.5644252665949368585885E+00 -0.9780668940114556342280E+00  0.1284572727460347139894E-01 -0.2078945360743530423875E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1356                             0                             0                             0                             0                             0                             0
  0.4512290916410887642307E+00 -0.2087723167897392873016E-01  0.5882064707066587683215E+00 -0.9658461279823766787445E+00  0.1284572727460346966422E-01 -0.2587976900056045415077E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1357                             0                             0                             0                             0                             0                             0
  0.4442829420928769978971E+00 -0.2087723167897392873016E-01  0.6116562785862794671132E+00 -0.9509780448516391704317E+00  0.1284572727460346966422E-01 -0.3089914974573577111094E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1358                             0                             0                             0                             0                             0                             0
  0.4361190438821173076533E+00 -0.2087723167897392873016E-01  0.6347104159403771372894E+00 -0.9335033970016367588229E+00  0.1284572727460346966422E-01 -0.3583383806923159942137E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1359                             0                             0                             0                             0                             0                             0
  0.4267597736863398272256E+00 -0.2087723167897392873016E-01  0.6573056929809374393514E+00 -0.9134700812274784142986E+00  0.1284572727460347313366E-01 -0.4067030833335918971194E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1360                             0                             0                             0                             0                             0                             0
  0.4162307846145961720552E+00 -0.2087723167897392873016E-01  0.6793801776241709111659E+00 -0.8909330074552023193135E+00  0.1284572727460347313366E-01 -0.4539530410930351922438E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1361                             0                             0                             0                             0                             0                             0
  0.4045609358940711053343E+00 -0.2087723167897392873016E-01  0.7008733652420487958423E+00 -0.8659539482374857266578E+00  0.1284572727460347139894E-01 -0.4999587451207314070523E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1362                             0                             0                             0                             0                             0                             0
  0.3917822137689462302923E+00 -0.2087723167897392873016E-01  0.7217263445012838118942E+00 -0.8386013694393710249386E+00  0.1284572727460346966422E-01 -0.5445940969797580244460E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1363                             0                             0                             0                             0                             0                             0
  0.3779296438283283876558E+00 -0.2087723167897392873016E-01  0.7418819588351992511122E+00 -0.8089502425780893402063E+00  0.1284572727460347139894E-01 -0.5877367542732349070533E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1364                             0                             0                             0                             0                             0                             0
  0.3630411950035446477791E+00 -0.2087723167897392873016E-01  0.7612849631059053212567E+00 -0.7770818393313433380953E+00  0.1284572727460347139894E-01 -0.6292684659763294607870E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1365                             0                             0                             0                             0                             0                             0
  0.3471576754979402434920E+00 -0.2087723167897392873016E-01  0.7798821750273823294464E+00 -0.7430835087772864611111E+00  0.1284572727460347313366E-01 -0.6690753965540977565851E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1366                             0                             0                             0                             0                             0                             0
  0.3303226209344299890702E+00 -0.2087723167897392873016E-01  0.7976226209344299267201E+00 -0.7070484379767720817256E+00  0.1284572727460346966422E-01 -0.7070484379767719707033E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1367                             0                             0                             0                             0                             0                             0
  0.3125821750273825028188E+00 -0.2087723167897392873016E-01  0.8144576754979400146084E+00 -0.6690753965540980896520E+00  0.1284572727460347313366E-01 -0.7430835087772861280442E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1368                             0                             0                             0                             0                             0                             0
  0.2939849631059053836069E+00 -0.2087723167897392873016E-01  0.8303411950035446409402E+00 -0.6292684659763295718093E+00  0.1284572727460346966422E-01 -0.7770818393313432270730E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1369                             0                             0                             0                             0                             0                             0
  0.2745819588351993134623E+00 -0.2087723167897392873016E-01  0.8452296438283284363280E+00 -0.5877367542732349070533E+00  0.1284572727460347139894E-01 -0.8089502425780893402063E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1370                             0                             0                             0                             0                             0                             0
  0.2544263445012839852666E+00 -0.2087723167897392873016E-01  0.8590822137689461124310E+00 -0.5445940969797583575129E+00  0.1284572727460347139894E-01 -0.8386013694393708028940E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1371                             0                             0                             0                             0                             0                             0
  0.2335733652420488026813E+00 -0.2087723167897392873016E-01  0.8718609358940710984953E+00 -0.4999587451207314625634E+00  0.1284572727460347139894E-01 -0.8659539482374857266578E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1372                             0                             0                             0                             0                             0                             0
  0.2120801776241709180049E+00 -0.2087723167897392873016E-01  0.8835307846145961097051E+00 -0.4539530410930352477550E+00  0.1284572727460347139894E-01 -0.8909330074552022082912E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1373                             0                             0                             0                             0                             0                             0
  0.1900056929809373906792E+00 -0.2087723167897392873016E-01  0.8940597736863398203866E+00 -0.4067030833335917305860E+00  0.1284572727460347139894E-01 -0.9134700812274784142986E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1374                             0                             0                             0                             0                             0                             0
  0.1674104159403770608616E+00 -0.2087723167897392873016E-01  0.9034190438821172453032E+00 -0.3583383806923158276803E+00  0.1284572727460346966422E-01 -0.9335033970016367588229E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1375                             0                             0                             0                             0                             0                             0
  0.1443562785862795294634E+00 -0.2087723167897392873016E-01  0.9115829420928769355470E+00 -0.3089914974573577666206E+00  0.1284572727460346966422E-01 -0.9509780448516391704317E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1376                             0                             0                             0                             0                             0                             0
  0.1209064707066586780160E+00 -0.2087723167897392873016E-01  0.9185290916410887573917E+00 -0.2587976900056043749743E+00  0.1284572727460346966422E-01 -0.9658461279823766787445E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1377                             0                             0                             0                             0                             0                             0
  0.9712526659493682379409E-01 -0.2087723167897392873016E-01  0.9242384536136618589097E+00 -0.2078945360743528758540E+00  0.1284572727460347139894E-01 -0.9780668940114557452503E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1378                             0                             0                             0                             0                             0                             0
  0.7307784887857275701872E-01 -0.2087723167897392873016E-01  0.9286953790462825208962E+00 -0.1564215576702936150166E+00  0.1284572727460347139894E-01 -0.9876068466686456215342E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1379                             0                             0                             0                             0                             0                             0
  0.4883012985801131466967E-01 -0.2087723167897392873016E-01  0.9318876518161368638360E+00 -0.1045198386493887965365E+00  0.1284572727460347139894E-01 -0.9944398376068269707062E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1380                             0                             0                             0                             0                             0                             0
  0.2444857084564997298792E-01 -0.2087723167897392873016E-01  0.9338065221254547854102E+00 -0.5233163801583134294715E-01  0.1284572727460347139894E-01 -0.9985471380727934942456E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1381                             0                             0                             0                             0                             0                             0
  0.2360593098356981805542E-15 -0.2087723167897392873016E-01  0.9344467304840977650571E+00 -0.5052798558483722020180E-15  0.1284572727460347139894E-01 -0.9999174902414631471714E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1382                             0                             0                             0                             0                             0                             0
 -0.2444857084564991400732E-01 -0.2087723167897392873016E-01  0.9338065221254547854102E+00  0.5233163801583121804706E-01  0.1284572727460347139894E-01 -0.9985471380727934942456E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1383                             0                             0                             0                             0                             0                             0
 -0.4883012985801125221963E-01 -0.2087723167897392873016E-01  0.9318876518161368638360E+00  0.1045198386493886716364E+00  0.1284572727460347139894E-01 -0.9944398376068269707062E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1384                             0                             0                             0                             0                             0                             0
 -0.7307784887857271538536E-01 -0.2087723167897392873016E-01  0.9286953790462825208962E+00  0.1564215576702935039943E+00  0.1284572727460347139894E-01 -0.9876068466686456215342E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1385                             0                             0                             0                             0                             0                             0
 -0.9712526659493676828294E-01 -0.2087723167897392873016E-01  0.9242384536136618589097E+00  0.2078945360743527648317E+00  0.1284572727460347139894E-01 -0.9780668940114557452503E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1386                             0                             0                             0                             0                             0                             0
 -0.1209064707066586363826E+00 -0.2087723167897392873016E-01  0.9185290916410888684140E+00  0.2587976900056042639520E+00  0.1284572727460347139894E-01 -0.9658461279823767897668E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1387                             0                             0                             0                             0                             0                             0
 -0.1443562785862794739522E+00 -0.2087723167897392873016E-01  0.9115829420928770465693E+00  0.3089914974573576555983E+00  0.1284572727460347313366E-01 -0.9509780448516392814540E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1388                             0                             0                             0                             0                             0                             0
 -0.1674104159403770053505E+00 -0.2087723167897392873016E-01  0.9034190438821173563255E+00  0.3583383806923157166580E+00  0.1284572727460347139894E-01 -0.9335033970016368698452E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1389                             0                             0                             0                             0                             0                             0
 -0.1900056929809375017015E+00 -0.2087723167897392873016E-01  0.8940597736863398203866E+00  0.4067030833335920081417E+00  0.1284572727460346966422E-01 -0.9134700812274783032763E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1390                             0                             0                             0                             0                             0                             0
 -0.2120801776241708624937E+00 -0.2087723167897392873016E-01  0.8835307846145961097051E+00  0.4539530410930351367327E+00  0.1284572727460347139894E-01 -0.8909330074552023193135E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1391                             0                             0                             0                             0                             0                             0
 -0.2335733652420487471701E+00 -0.2087723167897392873016E-01  0.8718609358940710984953E+00  0.4999587451207313515411E+00  0.1284572727460346966422E-01 -0.8659539482374857266578E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1392                             0                             0                             0                             0                             0                             0
 -0.2544263445012839297554E+00 -0.2087723167897392873016E-01  0.8590822137689461124310E+00  0.5445940969797582464906E+00  0.1284572727460346966422E-01 -0.8386013694393708028940E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1393                             0                             0                             0                             0                             0                             0
 -0.2745819588351992579511E+00 -0.2087723167897392873016E-01  0.8452296438283284363280E+00  0.5877367542732347960310E+00  0.1284572727460346966422E-01 -0.8089502425780893402063E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1394                             0                             0                             0                             0                             0                             0
 -0.2939849631059053280957E+00 -0.2087723167897392873016E-01  0.8303411950035446409402E+00  0.6292684659763294607870E+00  0.1284572727460347139894E-01 -0.7770818393313433380953E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1395                             0                             0                             0                             0                             0                             0
 -0.3125821750273824473076E+00 -0.2087723167897392873016E-01  0.8144576754979401256307E+00  0.6690753965540979786297E+00  0.1284572727460347139894E-01 -0.7430835087772862390665E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1396                             0                             0                             0                             0                             0                             0
 -0.3303226209344299335591E+00 -0.2087723167897392873016E-01  0.7976226209344299267201E+00  0.7070484379767719707033E+00  0.1284572727460346966422E-01 -0.7070484379767720817256E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1397                             0                             0                             0                             0                             0                             0
 -0.3471576754979400214474E+00 -0.2087723167897392873016E-01  0.7798821750273825514910E+00  0.7430835087772860170219E+00  0.1284572727460346966422E-01 -0.6690753965540980896520E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1398                             0                             0                             0                             0                             0                             0
 -0.3630411950035444812457E+00 -0.2087723167897392873016E-01  0.7612849631059055433013E+00  0.7770818393313430050284E+00  0.1284572727460347313366E-01 -0.6292684659763299048763E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1399                             0                             0                             0                             0                             0                             0
 -0.3779296438283283321447E+00 -0.2087723167897392873016E-01  0.7418819588351993621345E+00  0.8089502425780892291840E+00  0.1284572727460346966422E-01 -0.5877367542732350180756E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1400                             0                             0                             0                             0                             0                             0
 -0.3917822137689462302923E+00 -0.2087723167897392873016E-01  0.7217263445012838118942E+00  0.8386013694393710249386E+00  0.1284572727460347139894E-01 -0.5445940969797581354683E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1401                             0                             0                             0                             0                             0                             0
 -0.4045609358940709943120E+00 -0.2087723167897392873016E-01  0.7008733652420490178869E+00  0.8659539482374855046132E+00  0.1284572727460347139894E-01 -0.4999587451207319066526E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1402                             0                             0                             0                             0                             0                             0
 -0.4162307846145961165440E+00 -0.2087723167897392873016E-01  0.6793801776241709111659E+00  0.8909330074552022082912E+00  0.1284572727460347139894E-01 -0.4539530410930353032661E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1403                             0                             0                             0                             0                             0                             0
 -0.4267597736863396606921E+00 -0.2087723167897392873016E-01  0.6573056929809377724183E+00  0.9134700812274780812317E+00  0.1284572727460347313366E-01 -0.4067030833335925632532E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1404                             0                             0                             0                             0                             0                             0
 -0.4361190438821174186756E+00 -0.2087723167897392873016E-01  0.6347104159403769152448E+00  0.9335033970016369808675E+00  0.1284572727460347313366E-01 -0.3583383806923154946134E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1405                             0                             0                             0                             0                             0                             0
 -0.4442829420928769978971E+00 -0.2087723167897392873016E-01  0.6116562785862795781355E+00  0.9509780448516391704317E+00  0.1284572727460346966422E-01 -0.3089914974573578221317E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1406                             0                             0                             0                             0                             0                             0
 -0.4512290916410887642307E+00 -0.2087723167897392873016E-01  0.5882064707066586572992E+00  0.9658461279823766787445E+00  0.1284572727460346966422E-01 -0.2587976900056044304854E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1407                             0                             0                             0                             0                             0                             0
 -0.4569384536136619212598E+00 -0.2087723167897392873016E-01  0.5644252665949370806331E+00  0.9780668940114556342280E+00  0.1284572727460347313366E-01 -0.2078945360743533754544E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1408                             0                             0                             0                             0                             0                             0
 -0.4613953790462824722240E+00 -0.2087723167897392873016E-01  0.5403778488785727640575E+00  0.9876068466686455105119E+00  0.1284572727460346966422E-01 -0.1564215576702936705278E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1409                             0                             0                             0                             0                             0                             0
 -0.4645876518161368151638E+00 -0.2087723167897392873016E-01  0.5161301298580117657977E+00  0.9944398376068268596839E+00  0.1284572727460347139894E-01 -0.1045198386493897402261E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1410                             0                             0                             0                             0                             0                             0
 -0.4665065221254548477603E+00 -0.2087723167897392873016E-01  0.4917485708456497683905E+00  0.9985471380727936052679E+00  0.1284572727460347139894E-01 -0.5233163801583096130798E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1411                             0                             0                             0                             0                             0                             0
 -0.4671467304840977163849E+00 -0.2087723167897392873016E-01  0.4673000000000000486722E+00  0.9999174902414631471714E+00  0.1284572727460347139894E-01 -0.1224545753835662725594E-15
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1412                             0                             0                             0                             0                             0                             0
 -0.4665065221254547922491E+00 -0.2087723167897392873016E-01  0.4428514291543498848647E+00  0.9985471380727934942456E+00  0.1284572727460347139894E-01  0.5233163801583159968622E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1413                             0                             0                             0                             0                             0                             0
 -0.4645876518161368706750E+00 -0.2087723167897392873016E-01  0.4184698701419887756359E+00  0.9944398376068269707062E+00  0.1284572727460347139894E-01  0.1045198386493886161253E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1414                             0                             0                             0                             0                             0                             0
 -0.4613953790462825277352E+00 -0.2087723167897392873016E-01  0.3942221511214273332868E+00  0.9876068466686456215342E+00  0.1284572727460347139894E-01  0.1564215576702934207276E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1415                             0                             0                             0                             0                             0                             0
 -0.4569384536136619212598E+00 -0.2087723167897392873016E-01  0.3701747334050630167113E+00  0.9780668940114556342280E+00  0.1284572727460347139894E-01  0.2078945360743531534098E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1416                             0                             0                             0                             0                             0                             0
 -0.4512290916410887087196E+00 -0.2087723167897392873016E-01  0.3463935292933409959559E+00  0.9658461279823765677222E+00  0.1284572727460347139894E-01  0.2587976900056050411081E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1417                             0                             0                             0                             0                             0                             0
 -0.4442829420928770534083E+00 -0.2087723167897392873016E-01  0.3229437214137205192088E+00  0.9509780448516392814540E+00  0.1284572727460347139894E-01  0.3089914974573576000871E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1418                             0                             0                             0                             0                             0                             0
 -0.4361190438821174186756E+00 -0.2087723167897392873016E-01  0.2998895840596231820996E+00  0.9335033970016369808675E+00  0.1284572727460347139894E-01  0.3583383806923152725687E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1419                             0                             0                             0                             0                             0                             0
 -0.4267597736863398827367E+00 -0.2087723167897392873016E-01  0.2772943070190626579929E+00  0.9134700812274785253209E+00  0.1284572727460347139894E-01  0.4067030833335915640525E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1420                             0                             0                             0                             0                             0                             0
 -0.4162307846145961720552E+00 -0.2087723167897392873016E-01  0.2552198223758291306673E+00  0.8909330074552023193135E+00  0.1284572727460347139894E-01  0.4539530410930351367327E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1421                             0                             0                             0                             0                             0                             0
 -0.4045609358940710498231E+00 -0.2087723167897392873016E-01  0.2337266347579510794574E+00  0.8659539482374856156355E+00  0.1284572727460347139894E-01  0.4999587451207316846080E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          1422                             0                             0                             0                             0                             0                             0
