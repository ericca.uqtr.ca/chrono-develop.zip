  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            28                             0                             0                             0                             0                             0                             0
  0.2649967817816754611648E+00 -0.1150000000000000049960E+00  0.4253286330297060269245E+00  0.5723012797963426129266E-01  0.9983198634690081396670E+00 -0.9064361789755956758108E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            29                             0                             0                             0                             0                             0                             0
  0.2668302245273077022425E+00 -0.1150000000000000049960E+00  0.4392550133052885996676E+00  0.5762608812024575671851E-01  0.9983198634690080286447E+00 -0.6056745923230908920654E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            30                             0                             0                             0                             0                             0                             0
  0.2679323041746521361084E+00 -0.1150000000000000049960E+00  0.4532582629400181972734E+00  0.5786409915885994126317E-01  0.9983198634690079176224E+00 -0.3032528937129533308514E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            31                             0                             0                             0                             0                             0                             0
  0.2682999999999999829470E+00 -0.1150000000000000049960E+00  0.4672999999999999376499E+00  0.5794350872376390765295E-01  0.9983198634690081396670E+00 -0.1286604350253826193405E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            32                             0                             0                             0                             0                             0                             0
  0.2679323041746521361084E+00 -0.1150000000000000049960E+00  0.4813417370599817890486E+00  0.5786409915885994126317E-01  0.9983198634690079176224E+00  0.3032528937129533308514E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            33                             0                             0                             0                             0                             0                             0
  0.2668302245273077022425E+00 -0.1150000000000000049960E+00  0.4953449866947113866544E+00  0.5762608812024575671851E-01  0.9983198634690080286447E+00  0.6056745923230908920654E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            34                             0                             0                             0                             0                             0                             0
  0.2649967817816754611648E+00 -0.1150000000000000049960E+00  0.5092713669702939593975E+00  0.5723012797963426129266E-01  0.9983198634690081396670E+00  0.9064361789755956758108E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            35                             0                             0                             0                             0                             0                             0
  0.2624370012768800219938E+00 -0.1150000000000000049960E+00  0.5230827066464048824557E+00  0.5667730403624800239459E-01  0.9983198634690080286447E+00  0.1204713287067134611097E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            36                             0                             0                             0                             0                             0                             0
  0.2591578991933570219608E+00 -0.1150000000000000049960E+00  0.5367411498010062897990E+00  0.5596913154208948970592E-01  0.9983198634690081396670E+00  0.1499688359777415214147E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            37                             0                             0                             0                             0                             0                             0
  0.2551684633219896691791E+00 -0.1150000000000000049960E+00  0.5502092595907983607617E+00  0.5510755154874073802329E-01  0.9983198634690080286447E+00  0.1790552890935606655809E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            38                             0                             0                             0                             0                             0                             0
  0.2504796284291991859128E+00 -0.1150000000000000049960E+00  0.5634501208630040558489E+00  0.5409492558707584136668E-01  0.9983198634690081396670E+00  0.2076509641079549162157E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            39                             0                             0                             0                             0                             0                             0
  0.2451042462855098358343E+00 -0.1150000000000000049960E+00  0.5764274413372372229958E+00  0.5293402919446894144828E-01  0.9983198634690082506893E+00  0.2356774822633707355823E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            40                             0                             0                             0                             0                             0                             0
  0.2390570504397390994011E+00 -0.1150000000000000049960E+00  0.5891056510801203627281E+00  0.5162804430723925280811E-01  0.9983198634690082506893E+00  0.2630580248216436364816E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            41                             0                             0                             0                             0                             0                             0
  0.2323546158353649027095E+00 -0.1150000000000000049960E+00  0.6014499999999999291234E+00  0.5018055053918478447539E-01  0.9983198634690080286447E+00  0.2897175436188194341813E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            42                             0                             0                             0                             0                             0                             0
  0.2250153133797572757580E+00 -0.1150000000000000049960E+00  0.6134266530945317041912E+00  0.4859551537010971256070E-01  0.9983198634690081396670E+00  0.3155829667669556720666E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            43                             0                             0                             0                             0                             0                             0
  0.2170592595907983868297E+00 -0.1150000000000000049960E+00  0.6250027831900705210799E+00  0.4687728327123802385401E-01  0.9983198634690082506893E+00  0.3405833989390868316027E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            44                             0                             0                             0                             0                             0                             0
  0.2085082614589053029430E+00 -0.1150000000000000049960E+00  0.6361466609186713361268E+00  0.4503056379731988634330E-01  0.9983198634690081396670E+00  0.3646503156883876273220E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            45                             0                             0                             0                             0                             0                             0
  0.1993857566755849186624E+00 -0.1150000000000000049960E+00  0.6468277416860815920430E+00  0.4306041867806941619845E-01  0.9983198634690081396670E+00  0.3877177512689192195872E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            46                             0                             0                             0                             0                             0                             0
  0.1897167493923506975673E+00 -0.1150000000000000049960E+00  0.6570167493923506629727E+00  0.4097224794431533756445E-01  0.9983198634690082506893E+00  0.4097224794431533062555E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            47                             0                             0                             0                             0                             0                             0
  0.1795277416860816821487E+00 -0.1150000000000000049960E+00  0.6666857566755848285567E+00  0.3877177512689194277540E-01  0.9983198634690081396670E+00  0.4306041867806939538177E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            48                             0                             0                             0                             0                             0                             0
  0.1688466609186713707214E+00 -0.1150000000000000049960E+00  0.6758082614589052683485E+00  0.3646503156883876967109E-01  0.9983198634690080286447E+00  0.4503056379731988634330E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            49                             0                             0                             0                             0                             0                             0
  0.1577027831900705279189E+00 -0.1150000000000000049960E+00  0.6843592595907983522352E+00  0.3405833989390868316027E-01  0.9983198634690082506893E+00  0.4687728327123802385401E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            50                             0                             0                             0                             0                             0                             0
  0.1461266530945317942969E+00 -0.1150000000000000049960E+00  0.6923153133797572689190E+00  0.3155829667669558802334E-01  0.9983198634690082506893E+00  0.4859551537010970562180E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            51                             0                             0                             0                             0                             0                             0
  0.1341499999999999637179E+00 -0.1150000000000000049960E+00  0.6996546158353649236261E+00  0.2897175436188194688758E-01  0.9983198634690081396670E+00  0.5018055053918478447539E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            52                             0                             0                             0                             0                             0                             0
  0.1218056510801203973227E+00 -0.1150000000000000049960E+00  0.7063570504397390648066E+00  0.2630580248216436711761E-01  0.9983198634690080286447E+00  0.5162804430723924586921E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            53                             0                             0                             0                             0                             0                             0
  0.1091274413372371326902E+00 -0.1150000000000000049960E+00  0.7124042462855098012398E+00  0.2356774822633706314989E-01  0.9983198634690081396670E+00  0.5293402919446894144828E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            54                             0                             0                             0                             0                             0                             0
  0.9615012086300402105454E-01 -0.1150000000000000049960E+00  0.7177796284291991790738E+00  0.2076509641079548468268E-01  0.9983198634690080286447E+00  0.5409492558707584136668E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            55                             0                             0                             0                             0                             0                             0
  0.8290925959079839535626E-01 -0.1150000000000000049960E+00  0.7224684633219896623402E+00  0.1790552890935607002754E-01  0.9983198634690081396670E+00  0.5510755154874073802329E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            56                             0                             0                             0                             0                             0                             0
  0.6944114980100625500459E-01 -0.1150000000000000049960E+00  0.7264578991933570151218E+00  0.1499688359777414173313E-01  0.9983198634690080286447E+00  0.5596913154208948970592E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            57                             0                             0                             0                             0                             0                             0
  0.5578270664640479908902E-01 -0.1150000000000000049960E+00  0.7297370012768800151548E+00  0.1204713287067133570263E-01  0.9983198634690081396670E+00  0.5667730403624800239459E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            58                             0                             0                             0                             0                             0                             0
  0.4197136697029395235869E-01 -0.1150000000000000049960E+00  0.7322967817816754543259E+00  0.9064361789755960227555E-02  0.9983198634690081396670E+00  0.5723012797963426129266E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            59                             0                             0                             0                             0                             0                             0
  0.2804498669471136226838E-01 -0.1150000000000000049960E+00  0.7341302245273078064258E+00  0.6056745923230900247036E-02  0.9983198634690082506893E+00  0.5762608812024576365740E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            60                             0                             0                             0                             0                             0                             0
  0.1404173705998180629595E-01 -0.1150000000000000049960E+00  0.7352323041746521292694E+00  0.3032528937129537211642E-02  0.9983198634690079176224E+00  0.5786409915885994126317E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            61                             0                             0                             0                             0                             0                             0
  0.1355777718133335429990E-15 -0.1150000000000000049960E+00  0.7356000000000000316192E+00  0.2928010362957273264838E-16  0.9983198634690081396670E+00  0.5794350872376390765295E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            62                             0                             0                             0                             0                             0                             0
 -0.1404173705998177160148E-01 -0.1150000000000000049960E+00  0.7352323041746521292694E+00 -0.3032528937129529839067E-02  0.9983198634690079176224E+00  0.5786409915885994126317E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            63                             0                             0                             0                             0                             0                             0
 -0.2804498669471132757391E-01 -0.1150000000000000049960E+00  0.7341302245273078064258E+00 -0.6056745923230893308142E-02  0.9983198634690082506893E+00  0.5762608812024576365740E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            64                             0                             0                             0                             0                             0                             0
 -0.4197136697029392460312E-01 -0.1150000000000000049960E+00  0.7322967817816754543259E+00 -0.9064361789755955023384E-02  0.9983198634690081396670E+00  0.5723012797963426129266E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            65                             0                             0                             0                             0                             0                             0
 -0.5578270664640477133345E-01 -0.1150000000000000049960E+00  0.7297370012768800151548E+00 -0.1204713287067133049846E-01  0.9983198634690081396670E+00  0.5667730403624800239459E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            66                             0                             0                             0                             0                             0                             0
 -0.6944114980100622724901E-01 -0.1150000000000000049960E+00  0.7264578991933570151218E+00 -0.1499688359777413479423E-01  0.9983198634690082506893E+00  0.5596913154208949664481E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            67                             0                             0                             0                             0                             0                             0
 -0.8290925959079836760068E-01 -0.1150000000000000049960E+00  0.7224684633219897733625E+00 -0.1790552890935606308864E-01  0.9983198634690082506893E+00  0.5510755154874074496218E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            68                             0                             0                             0                             0                             0                             0
 -0.9615012086300399329897E-01 -0.1150000000000000049960E+00  0.7177796284291992900961E+00 -0.2076509641079547774378E-01  0.9983198634690081396670E+00  0.5409492558707584830557E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            69                             0                             0                             0                             0                             0                             0
 -0.1091274413372372020792E+00 -0.1150000000000000049960E+00  0.7124042462855098012398E+00 -0.2356774822633708049713E-01  0.9983198634690081396670E+00  0.5293402919446893450939E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            70                             0                             0                             0                             0                             0                             0
 -0.1218056510801203695671E+00 -0.1150000000000000049960E+00  0.7063570504397390648066E+00 -0.2630580248216436017872E-01  0.9983198634690081396670E+00  0.5162804430723925280811E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            71                             0                             0                             0                             0                             0                             0
 -0.1341499999999999359623E+00 -0.1150000000000000049960E+00  0.6996546158353649236261E+00 -0.2897175436188193994869E-01  0.9983198634690080286447E+00  0.5018055053918478447539E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            72                             0                             0                             0                             0                             0                             0
 -0.1461266530945317665413E+00 -0.1150000000000000049960E+00  0.6923153133797572689190E+00 -0.3155829667669558108445E-01  0.9983198634690080286447E+00  0.4859551537010970562180E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            73                             0                             0                             0                             0                             0                             0
 -0.1577027831900705001633E+00 -0.1150000000000000049960E+00  0.6843592595907983522352E+00 -0.3405833989390868316027E-01  0.9983198634690080286447E+00  0.4687728327123802385401E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            74                             0                             0                             0                             0                             0                             0
 -0.1688466609186713429658E+00 -0.1150000000000000049960E+00  0.6758082614589052683485E+00 -0.3646503156883876273220E-01  0.9983198634690081396670E+00  0.4503056379731988634330E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            75                             0                             0                             0                             0                             0                             0
 -0.1795277416860816543931E+00 -0.1150000000000000049960E+00  0.6666857566755848285567E+00 -0.3877177512689193583650E-01  0.9983198634690080286447E+00  0.4306041867806940232066E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            76                             0                             0                             0                             0                             0                             0
 -0.1897167493923506698117E+00 -0.1150000000000000049960E+00  0.6570167493923506629727E+00 -0.4097224794431533062555E-01  0.9983198634690082506893E+00  0.4097224794431533756445E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            77                             0                             0                             0                             0                             0                             0
 -0.1993857566755848076401E+00 -0.1150000000000000049960E+00  0.6468277416860817030653E+00 -0.4306041867806938844288E-01  0.9983198634690079176224E+00  0.3877177512689194277540E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            78                             0                             0                             0                             0                             0                             0
 -0.2085082614589052196763E+00 -0.1150000000000000049960E+00  0.6361466609186714471491E+00 -0.4503056379731987246551E-01  0.9983198634690081396670E+00  0.3646503156883878354888E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            79                             0                             0                             0                             0                             0                             0
 -0.2170592595907983590742E+00 -0.1150000000000000049960E+00  0.6250027831900705210799E+00 -0.4687728327123801691512E-01  0.9983198634690080286447E+00  0.3405833989390869009917E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            80                             0                             0                             0                             0                             0                             0
 -0.2250153133797572757580E+00 -0.1150000000000000049960E+00  0.6134266530945317041912E+00 -0.4859551537010971256070E-01  0.9983198634690082506893E+00  0.3155829667669557414555E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            81                             0                             0                             0                             0                             0                             0
 -0.2323546158353648194428E+00 -0.1150000000000000049960E+00  0.6014500000000000401457E+00 -0.5018055053918477059760E-01  0.9983198634690082506893E+00  0.2897175436188197464316E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            82                             0                             0                             0                             0                             0                             0
 -0.2390570504397390716456E+00 -0.1150000000000000049960E+00  0.5891056510801203627281E+00 -0.5162804430723924586921E-01  0.9983198634690080286447E+00  0.2630580248216437058706E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            83                             0                             0                             0                             0                             0                             0
 -0.2451042462855097248120E+00 -0.1150000000000000049960E+00  0.5764274413372373340181E+00 -0.5293402919446892063160E-01  0.9983198634690082506893E+00  0.2356774822633711172215E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            84                             0                             0                             0                             0                             0                             0
 -0.2504796284291992969351E+00 -0.1150000000000000049960E+00  0.5634501208630039448266E+00 -0.5409492558707584830557E-01  0.9983198634690082506893E+00  0.2076509641079546386599E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            85                             0                             0                             0                             0                             0                             0
 -0.2551684633219896691791E+00 -0.1150000000000000049960E+00  0.5502092595907983607617E+00 -0.5510755154874073802329E-01  0.9983198634690081396670E+00  0.1790552890935607349698E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            86                             0                             0                             0                             0                             0                             0
 -0.2591578991933570219608E+00 -0.1150000000000000049960E+00  0.5367411498010062897990E+00 -0.5596913154208948970592E-01  0.9983198634690080286447E+00  0.1499688359777414520257E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            87                             0                             0                             0                             0                             0                             0
 -0.2624370012768800219938E+00 -0.1150000000000000049960E+00  0.5230827066464048824557E+00 -0.5667730403624800239459E-01  0.9983198634690081396670E+00  0.1204713287067136519293E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            88                             0                             0                             0                             0                             0                             0
 -0.2649967817816754056537E+00 -0.1150000000000000049960E+00  0.5092713669702939593975E+00 -0.5723012797963425435377E-01  0.9983198634690081396670E+00  0.9064361789755963697002E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            89                             0                             0                             0                             0                             0                             0
 -0.2668302245273077022425E+00 -0.1150000000000000049960E+00  0.4953449866947116086990E+00 -0.5762608812024575671851E-01  0.9983198634690082506893E+00  0.6056745923230954890826E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            90                             0                             0                             0                             0                             0                             0
 -0.2679323041746521916195E+00 -0.1150000000000000049960E+00  0.4813417370599816780263E+00 -0.5786409915885994820206E-01  0.9983198634690081396670E+00  0.3032528937129515093918E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            91                             0                             0                             0                             0                             0                             0
 -0.2682999999999999829470E+00 -0.1150000000000000049960E+00  0.4673000000000000486722E+00 -0.5794350872376390765295E-01  0.9983198634690081396670E+00  0.7096033248992420642038E-17
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            92                             0                             0                             0                             0                             0                             0
 -0.2679323041746521361084E+00 -0.1150000000000000049960E+00  0.4532582629400181417623E+00 -0.5786409915885994126317E-01  0.9983198634690080286447E+00 -0.3032528937129551956792E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            93                             0                             0                             0                             0                             0                             0
 -0.2668302245273077577536E+00 -0.1150000000000000049960E+00  0.4392550133052886551788E+00 -0.5762608812024576365740E-01  0.9983198634690082506893E+00 -0.6056745923230889838695E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            94                             0                             0                             0                             0                             0                             0
 -0.2649967817816754611648E+00 -0.1150000000000000049960E+00  0.4253286330297060824357E+00 -0.5723012797963426129266E-01  0.9983198634690081396670E+00 -0.9064361789755949819214E-02
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            95                             0                             0                             0                             0                             0                             0
 -0.2624370012768800219938E+00 -0.1150000000000000049960E+00  0.4115172933535951038664E+00 -0.5667730403624800239459E-01  0.9983198634690080286447E+00 -0.1204713287067135304986E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            96                             0                             0                             0                             0                             0                             0
 -0.2591578991933569664496E+00 -0.1150000000000000049960E+00  0.3978588501989935855008E+00 -0.5596913154208948276702E-01  0.9983198634690081396670E+00 -0.1499688359777417989704E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            97                             0                             0                             0                             0                             0                             0
 -0.2551684633219897246903E+00 -0.1150000000000000049960E+00  0.3843907404092016255603E+00 -0.5510755154874074496218E-01  0.9983198634690082506893E+00 -0.1790552890935605961920E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            98                             0                             0                             0                             0                             0                             0
 -0.2504796284291992969351E+00 -0.1150000000000000049960E+00  0.3711498791369960970066E+00 -0.5409492558707584830557E-01  0.9983198634690080286447E+00 -0.2076509641079544998821E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                            99                             0                             0                             0                             0                             0                             0
 -0.2451042462855098635899E+00 -0.1150000000000000049960E+00  0.3581725586627628743486E+00 -0.5293402919446894838718E-01  0.9983198634690081396670E+00 -0.2356774822633705274155E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           100                             0                             0                             0                             0                             0                             0
 -0.2390570504397390994011E+00 -0.1150000000000000049960E+00  0.3454943489198796235939E+00 -0.5162804430723925280811E-01  0.9983198634690081396670E+00 -0.2630580248216436017872E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           101                             0                             0                             0                             0                             0                             0
 -0.2323546158353648471984E+00 -0.1150000000000000049960E+00  0.3331499999999999461764E+00 -0.5018055053918477753649E-01  0.9983198634690081396670E+00 -0.2897175436188196076537E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           102                             0                             0                             0                             0                             0                             0
 -0.2250153133797573312691E+00 -0.1150000000000000049960E+00  0.3211733469054683376420E+00 -0.4859551537010971949959E-01  0.9983198634690082506893E+00 -0.3155829667669556026777E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           103                             0                             0                             0                             0                             0                             0
 -0.2170592595907984145853E+00 -0.1150000000000000049960E+00  0.3095972168099294652421E+00 -0.4687728327123803079290E-01  0.9983198634690082506893E+00 -0.3405833989390868316027E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           104                             0                             0                             0                             0                             0                             0
 -0.2085082614589053862098E+00 -0.1150000000000000049960E+00  0.2984533390813287612175E+00 -0.4503056379731990715998E-01  0.9983198634690080286447E+00 -0.3646503156883873497662E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           105                             0                             0                             0                             0                             0                             0
 -0.1993857566755847798845E+00 -0.1150000000000000049960E+00  0.2877722583139182832568E+00 -0.4306041867806938150398E-01  0.9983198634690080286447E+00 -0.3877177512689195665319E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           106                             0                             0                             0                             0                             0                             0
 -0.1897167493923507253228E+00 -0.1150000000000000049960E+00  0.2775832506076493233493E+00 -0.4097224794431534450334E-01  0.9983198634690083617116E+00 -0.4097224794431533062555E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           107                             0                             0                             0                             0                             0                             0
 -0.1795277416860816266375E+00 -0.1150000000000000049960E+00  0.2679142433244151022542E+00 -0.3877177512689192889761E-01  0.9983198634690081396670E+00 -0.4306041867806940925956E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           108                             0                             0                             0                             0                             0                             0
 -0.1688466609186714817437E+00 -0.1150000000000000049960E+00  0.2587917385410948289959E+00 -0.3646503156883879048777E-01  0.9983198634690080286447E+00 -0.4503056379731986552661E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           109                             0                             0                             0                             0                             0                             0
 -0.1577027831900705556745E+00 -0.1150000000000000049960E+00  0.2502407404092016340869E+00 -0.3405833989390869009917E-01  0.9983198634690080286447E+00 -0.4687728327123801691512E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           110                             0                             0                             0                             0                             0                             0
 -0.1461266530945319330748E+00 -0.1150000000000000049960E+00  0.2422846866202428561810E+00 -0.3155829667669561577892E-01  0.9983198634690082506893E+00 -0.4859551537010968480512E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           111                             0                             0                             0                             0                             0                             0
 -0.1341499999999998804512E+00 -0.1150000000000000049960E+00  0.2349453841646350626959E+00 -0.2897175436188193300979E-01  0.9983198634690080286447E+00 -0.5018055053918479141428E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           112                             0                             0                             0                             0                             0                             0
 -0.1218056510801204250782E+00 -0.1150000000000000049960E+00  0.2282429495602609215155E+00 -0.2630580248216437405651E-01  0.9983198634690081396670E+00 -0.5162804430723924586921E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           113                             0                             0                             0                             0                             0                             0
 -0.1091274413372371604458E+00 -0.1150000000000000049960E+00  0.2221957537144901573267E+00 -0.2356774822633707008879E-01  0.9983198634690082506893E+00 -0.5293402919446894144828E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           114                             0                             0                             0                             0                             0                             0
 -0.9615012086300417371021E-01 -0.1150000000000000049960E+00  0.2168203715708008072482E+00 -0.2076509641079551590770E-01  0.9983198634690081396670E+00 -0.5409492558707583442779E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           115                             0                             0                             0                             0                             0                             0
 -0.8290925959079842311183E-01 -0.1150000000000000049960E+00  0.2121315366780103239819E+00 -0.1790552890935607696643E-01  0.9983198634690081396670E+00 -0.5510755154874073802329E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           116                             0                             0                             0                             0                             0                             0
 -0.6944114980100628276016E-01 -0.1150000000000000049960E+00  0.2081421008066429712002E+00 -0.1499688359777414867202E-01  0.9983198634690080286447E+00 -0.5596913154208948970592E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           117                             0                             0                             0                             0                             0                             0
 -0.5578270664640471582230E-01 -0.1150000000000000049960E+00  0.2048629987231199711673E+00 -0.1204713287067131835539E-01  0.9983198634690080286447E+00 -0.5667730403624800239459E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           118                             0                             0                             0                             0                             0                             0
 -0.4197136697029398705316E-01 -0.1150000000000000049960E+00  0.2023032182183245875073E+00 -0.9064361789755967166449E-02  0.9983198634690081396670E+00 -0.5723012797963425435377E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           119                             0                             0                             0                             0                             0                             0
 -0.2804498669471139349341E-01 -0.1150000000000000049960E+00  0.2004697754726922354074E+00 -0.6056745923230908053292E-02  0.9983198634690082506893E+00 -0.5762608812024576365740E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           120                             0                             0                             0                             0                             0                             0
 -0.1404173705998195721689E-01 -0.1150000000000000049960E+00  0.1993676958253478570526E+00 -0.3032528937129569737707E-02  0.9983198634690080286447E+00 -0.5786409915885994126317E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           121                             0                             0                             0                             0                             0                             0
  0.1851223700959694400072E-16 -0.1226772188959260462271E+00  0.1649722264331905940971E+00  0.2025286161845667300435E-16  0.9437168922604080023575E+00 -0.3307543306781596803567E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           122                             0                             0                             0                             0                             0                             0
  0.1582261312841920855576E-01 -0.1226772188959260462271E+00  0.1653865561395909677955E+00  0.1731034417753638324222E-01  0.9437168922604078913352E+00 -0.3303010433631910491847E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           123                             0                             0                             0                             0                             0                             0
  0.3160185757406968470873E-01 -0.1226772188959260462271E+00  0.1666284096098665790109E+00  0.3457324190490931870023E-01  0.9437168922604078913352E+00 -0.3289424238473079853406E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           124                             0                             0                             0                             0                             0                             0
  0.4729448352472789829370E-01 -0.1226772188959260462271E+00  0.1686943830099754682017E+00  0.5174137677937754725699E-01  0.9437168922604081133798E+00 -0.3266821960121670254118E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           125                             0                             0                             0                             0                             0                             0
  0.6285747858344406524544E-01 -0.1226772188959260462271E+00  0.1715788136504321492737E+00  0.6876769213659250645776E-01  0.9437168922604080023575E+00 -0.3235265549851576438734E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           126                             0                             0                             0                             0                             0                             0
  0.7824818566253272100752E-01 -0.1226772188959260462271E+00  0.1752737955073452869037E+00  0.8560552002964466611346E-01  0.9437168922604080023575E+00 -0.3194841501589891219481E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           127                             0                             0                             0                             0                             0                             0
  0.9342441990368512139131E-01 -0.1226772188959260462271E+00  0.1797692008922802675563E+00  0.1022087091426623767232E+00  0.9437168922604078913352E+00 -0.3145660614843057700796E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           128                             0                             0                             0                             0                             0                             0
  0.1083445843037333516934E+00 -0.1226772188959260462271E+00  0.1850527082115486221525E+00  0.1185317512883603263685E+00  0.9437168922604081133798E+00 -0.3087857691003128013385E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           129                             0                             0                             0                             0                             0                             0
  0.1229677837291447001222E+00 -0.1226772188959260462271E+00  0.1911098357388404944679E+00  0.1345299061428178177824E+00  0.9437168922604080023575E+00 -0.3021591163866515494796E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           130                             0                             0                             0                             0                             0                             0
  0.1372539370067403508013E+00 -0.1226772188959260462271E+00  0.1979239813086292598676E+00  0.1501593238755970227682E+00  0.9437168922604080023575E+00 -0.2947042665377970771523E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           131                             0                             0                             0                             0                             0                             0
  0.1511638867834046717764E+00 -0.1226772188959260462271E+00  0.2054764678215535433914E+00  0.1653771653390798124228E+00  0.9437168922604080023575E+00 -0.2864416527790050182034E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           132                             0                             0                             0                             0                             0                             0
  0.1646595068536686745642E+00 -0.1226772188959260462271E+00  0.2137465944370484094428E+00  0.1801417194875940541721E+00  0.9437168922604080023575E+00 -0.2773939223602607806463E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           133                             0                             0                             0                             0                             0                             0
  0.1777038066609887556613E+00 -0.1226772188959260462271E+00  0.2227116933129101583599E+00  0.1944125177044901675583E+00  0.9437168922604080023575E+00 -0.2675858744817422030238E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           134                             0                             0                             0                             0                             0                             0
  0.1902610326862912148993E+00 -0.1226772188959260462271E+00  0.2323471917362765482018E+00  0.2081504447238067267989E+00  0.9437168922604080023575E+00 -0.2570443923209352332648E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           135                             0                             0                             0                             0                             0                             0
  0.2022967664458827641294E+00 -0.1226772188959260462271E+00  0.2426266794757242772906E+00  0.2213178458424952810280E+00  0.9437168922604078913352E+00 -0.2457983693477132913774E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           136                             0                             0                             0                             0                             0                             0
  0.2137780188301219574942E+00 -0.1226772188959260462271E+00  0.2535219811698780079112E+00  0.2338786301293444280791E+00  0.9437168922604080023575E+00 -0.2338786301293444558347E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           137                             0                             0                             0                             0                             0                             0
  0.2246733205242757436260E+00 -0.1226772188959260462271E+00  0.2650032335541172567872E+00  0.2457983693477133191330E+00  0.9437168922604080023575E+00 -0.2213178458424952810280E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           138                             0                             0                             0                             0                             0                             0
  0.2349528082637234727148E+00 -0.1226772188959260462271E+00  0.2770389673137088060173E+00  0.2570443923209352887760E+00  0.9437168922604080023575E+00 -0.2081504447238066712877E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           139                             0                             0                             0                             0                             0                             0
  0.2445883066870898348011E+00 -0.1226772188959260462271E+00  0.2895961933390112097442E+00  0.2675858744817422030238E+00  0.9437168922604080023575E+00 -0.1944125177044901675583E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           140                             0                             0                             0                             0                             0                             0
  0.2535534055629515837182E+00 -0.1226772188959260462271E+00  0.3026404931463313463524E+00  0.2773939223602607806463E+00  0.9437168922604080023575E+00 -0.1801417194875940541721E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           141                             0                             0                             0                             0                             0                             0
  0.2618235321784464497696E+00 -0.1226772188959260462271E+00  0.3161361132165952936290E+00  0.2864416527790049626923E+00  0.9437168922604078913352E+00 -0.1653771653390798401784E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           142                             0                             0                             0                             0                             0                             0
  0.2693760186913707888046E+00 -0.1226772188959260462271E+00  0.3300460629932596701153E+00  0.2947042665377971326635E+00  0.9437168922604080023575E+00 -0.1501593238755970227682E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           143                             0                             0                             0                             0                             0                             0
  0.2761901642611594986931E+00 -0.1226772188959260462271E+00  0.3443322162708552514054E+00  0.3021591163866515494796E+00  0.9437168922604080023575E+00 -0.1345299061428178732935E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           144                             0                             0                             0                             0                             0                             0
  0.2822472917884513710085E+00 -0.1226772188959260462271E+00  0.3589554156962666553454E+00  0.3087857691003128013385E+00  0.9437168922604081133798E+00 -0.1185317512883603124907E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           145                             0                             0                             0                             0                             0                             0
  0.2875307991077197256047E+00 -0.1226772188959260462271E+00  0.3738755800963148856475E+00  0.3145660614843057700796E+00  0.9437168922604078913352E+00 -0.1022087091426623628454E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           146                             0                             0                             0                             0                             0                             0
  0.2920262044926547062573E+00 -0.1226772188959260462271E+00  0.3890518143374672721535E+00  0.3194841501589891219481E+00  0.9437168922604080023575E+00 -0.8560552002964465223567E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           147                             0                             0                             0                             0                             0                             0
  0.2957211863495678993985E+00 -0.1226772188959260462271E+00  0.4044425214165560111823E+00  0.3235265549851576993845E+00  0.9437168922604081133798E+00 -0.6876769213659240931324E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           148                             0                             0                             0                             0                             0                             0
  0.2986056169900245249593E+00 -0.1226772188959260462271E+00  0.4200055164752721226229E+00  0.3266821960121670254118E+00  0.9437168922604080023575E+00 -0.5174137677937753337920E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           149                             0                             0                             0                             0                             0                             0
  0.3006715903901334141501E+00 -0.1226772188959260462271E+00  0.4356981424259303015134E+00  0.3289424238473079853406E+00  0.9437168922604078913352E+00 -0.3457324190490929788355E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           150                             0                             0                             0                             0                             0                             0
  0.3019134438604090253655E+00 -0.1226772188959260462271E+00  0.4514773868715808990970E+00  0.3303010433631910491847E+00  0.9437168922604078913352E+00 -0.1731034417753628956715E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           151                             0                             0                             0                             0                             0                             0
  0.3023277735668093990640E+00 -0.1226772188959260462271E+00  0.4672999999999999376499E+00  0.3307543306781596803567E+00  0.9437168922604080023575E+00 -0.7344221468267512883549E-16
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           152                             0                             0                             0                             0                             0                             0
  0.3019134438604090253655E+00 -0.1226772188959260462271E+00  0.4831226131284190872250E+00  0.3303010433631910491847E+00  0.9437168922604078913352E+00  0.1731034417753628956715E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           153                             0                             0                             0                             0                             0                             0
  0.3006715903901334141501E+00 -0.1226772188959260462271E+00  0.4989018575740696848086E+00  0.3289424238473079853406E+00  0.9437168922604078913352E+00  0.3457324190490929788355E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           154                             0                             0                             0                             0                             0                             0
  0.2986056169900245249593E+00 -0.1226772188959260462271E+00  0.5145944835247279192103E+00  0.3266821960121670254118E+00  0.9437168922604080023575E+00  0.5174137677937753337920E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           155                             0                             0                             0                             0                             0                             0
  0.2957211863495678438873E+00 -0.1226772188959260462271E+00  0.5301574785834440861620E+00  0.3235265549851576438734E+00  0.9437168922604080023575E+00  0.6876769213659249257997E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           156                             0                             0                             0                             0                             0                             0
  0.2920262044926547062573E+00 -0.1226772188959260462271E+00  0.5455481856625327141685E+00  0.3194841501589891219481E+00  0.9437168922604080023575E+00  0.8560552002964465223567E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           157                             0                             0                             0                             0                             0                             0
  0.2875307991077197256047E+00 -0.1226772188959260462271E+00  0.5607244199036851561857E+00  0.3145660614843057700796E+00  0.9437168922604078913352E+00  0.1022087091426623628454E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           158                             0                             0                             0                             0                             0                             0
  0.2822472917884513710085E+00 -0.1226772188959260462271E+00  0.5756445843037333309766E+00  0.3087857691003128013385E+00  0.9437168922604081133798E+00  0.1185317512883603124907E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           159                             0                             0                             0                             0                             0                             0
  0.2761901642611595542043E+00 -0.1226772188959260462271E+00  0.5902677837291446794055E+00  0.3021591163866515494796E+00  0.9437168922604081133798E+00  0.1345299061428178177824E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           160                             0                             0                             0                             0                             0                             0
  0.2693760186913707888046E+00 -0.1226772188959260462271E+00  0.6045539370067403162068E+00  0.2947042665377971326635E+00  0.9437168922604080023575E+00  0.1501593238755970227682E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           161                             0                             0                             0                             0                             0                             0
  0.2618235321784464497696E+00 -0.1226772188959260462271E+00  0.6184638867834046926930E+00  0.2864416527790050182034E+00  0.9437168922604080023575E+00  0.1653771653390797846672E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           162                             0                             0                             0                             0                             0                             0
  0.2535534055629516392294E+00 -0.1226772188959260462271E+00  0.6319595068536686399696E+00  0.2773939223602608361574E+00  0.9437168922604080023575E+00  0.1801417194875939709053E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           163                             0                             0                             0                             0                             0                             0
  0.2445883066870898348011E+00 -0.1226772188959260462271E+00  0.6450038066609887765779E+00  0.2675858744817422030238E+00  0.9437168922604080023575E+00  0.1944125177044901675583E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           164                             0                             0                             0                             0                             0                             0
  0.2349528082637235282260E+00 -0.1226772188959260462271E+00  0.6575610326862911803047E+00  0.2570443923209353442871E+00  0.9437168922604080023575E+00  0.2081504447238066435322E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           165                             0                             0                             0                             0                             0                             0
  0.2246733205242757991371E+00 -0.1226772188959260462271E+00  0.6695967664458827295348E+00  0.2457983693477134023997E+00  0.9437168922604080023575E+00  0.2213178458424952255168E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           166                             0                             0                             0                             0                             0                             0
  0.2137780188301219852498E+00 -0.1226772188959260462271E+00  0.6810780188301219784108E+00  0.2338786301293444558347E+00  0.9437168922604080023575E+00  0.2338786301293444280791E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           167                             0                             0                             0                             0                             0                             0
  0.2022967664458827918850E+00 -0.1226772188959260462271E+00  0.6919733205242757367870E+00  0.2213178458424953365391E+00  0.9437168922604080023575E+00  0.2457983693477132913774E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           168                             0                             0                             0                             0                             0                             0
  0.1902610326862911871437E+00 -0.1226772188959260462271E+00  0.7022528082637234936314E+00  0.2081504447238066712877E+00  0.9437168922604080023575E+00  0.2570443923209352887760E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           169                             0                             0                             0                             0                             0                             0
  0.1777038066609887556613E+00 -0.1226772188959260462271E+00  0.7118883066870898002065E+00  0.1944125177044901675583E+00  0.9437168922604080023575E+00  0.2675858744817422030238E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           170                             0                             0                             0                             0                             0                             0
  0.1646595068536687300753E+00 -0.1226772188959260462271E+00  0.7208534055629516323904E+00  0.1801417194875940819276E+00  0.9437168922604080023575E+00  0.2773939223602607251351E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           171                             0                             0                             0                             0                             0                             0
  0.1511638867834046717764E+00 -0.1226772188959260462271E+00  0.7291235321784463874195E+00  0.1653771653390798124228E+00  0.9437168922604080023575E+00  0.2864416527790050182034E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           172                             0                             0                             0                             0                             0                             0
  0.1372539370067403508013E+00 -0.1226772188959260462271E+00  0.7366760186913707819656E+00  0.1501593238755970227682E+00  0.9437168922604080023575E+00  0.2947042665377970771523E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           173                             0                             0                             0                             0                             0                             0
  0.1229677837291446307333E+00 -0.1226772188959260462271E+00  0.7434901642611595473653E+00  0.1345299061428177622712E+00  0.9437168922604080023575E+00  0.3021591163866515494796E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           174                             0                             0                             0                             0                             0                             0
  0.1083445843037332823044E+00 -0.1226772188959260462271E+00  0.7495472917884513641695E+00  0.1185317512883602569795E+00  0.9437168922604080023575E+00  0.3087857691003128013385E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           175                             0                             0                             0                             0                             0                             0
  0.9342441990368512139131E-01 -0.1226772188959260462271E+00  0.7548307991077196632546E+00  0.1022087091426623767232E+00  0.9437168922604078913352E+00  0.3145660614843057700796E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           176                             0                             0                             0                             0                             0                             0
  0.7824818566253265161858E-01 -0.1226772188959260462271E+00  0.7593262044926547549295E+00  0.8560552002964459672452E-01  0.9437168922604078913352E+00  0.3194841501589891219481E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           177                             0                             0                             0                             0                             0                             0
  0.6285747858344399585651E-01 -0.1226772188959260462271E+00  0.7630211863495679480707E+00  0.6876769213659243706882E-01  0.9437168922604081133798E+00  0.3235265549851576993845E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           178                             0                             0                             0                             0                             0                             0
  0.4729448352472789829370E-01 -0.1226772188959260462271E+00  0.7659056169900244626092E+00  0.5174137677937754725699E-01  0.9437168922604081133798E+00  0.3266821960121670254118E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           179                             0                             0                             0                             0                             0                             0
  0.3160185757406962225868E-01 -0.1226772188959260462271E+00  0.7679715903901334073112E+00  0.3457324190490924237240E-01  0.9437168922604080023575E+00  0.3289424238473080408518E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           180                             0                             0                             0                             0                             0                             0
  0.1582261312841914263627E-01 -0.1226772188959260462271E+00  0.7692134438604090185265E+00  0.1731034417753631038384E-01  0.9437168922604078913352E+00  0.3303010433631910491847E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           181                             0                             0                             0                             0                             0                             0
  0.1527727390886099799052E-15 -0.1226772188959260462271E+00  0.7696277735668093367138E+00  0.1671372909838069337568E-15  0.9437168922604080023575E+00  0.3307543306781596803567E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           182                             0                             0                             0                             0                             0                             0
 -0.1582261312841910447236E-01 -0.1226772188959260462271E+00  0.7692134438604090185265E+00 -0.1731034417753626875047E-01  0.9437168922604078913352E+00  0.3303010433631910491847E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           183                             0                             0                             0                             0                             0                             0
 -0.3160185757406958062532E-01 -0.1226772188959260462271E+00  0.7679715903901334073112E+00 -0.3457324190490920767793E-01  0.9437168922604080023575E+00  0.3289424238473080408518E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           184                             0                             0                             0                             0                             0                             0
 -0.4729448352472786359924E-01 -0.1226772188959260462271E+00  0.7659056169900244626092E+00 -0.5174137677937751256252E-01  0.9437168922604080023575E+00  0.3266821960121670254118E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           185                             0                             0                             0                             0                             0                             0
 -0.6285747858344396810093E-01 -0.1226772188959260462271E+00  0.7630211863495679480707E+00 -0.6876769213659239543546E-01  0.9437168922604081133798E+00  0.3235265549851576993845E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           186                             0                             0                             0                             0                             0                             0
 -0.7824818566253262386301E-01 -0.1226772188959260462271E+00  0.7593262044926547549295E+00 -0.8560552002964455509115E-01  0.9437168922604080023575E+00  0.3194841501589891774593E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           187                             0                             0                             0                             0                             0                             0
 -0.9342441990368509363574E-01 -0.1226772188959260462271E+00  0.7548307991077197742769E+00 -0.1022087091426623489676E+00  0.9437168922604081133798E+00  0.3145660614843058255907E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           188                             0                             0                             0                             0                             0                             0
 -0.1083445843037332545489E+00 -0.1226772188959260462271E+00  0.7495472917884513641695E+00 -0.1185317512883602153462E+00  0.9437168922604081133798E+00  0.3087857691003128568497E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           189                             0                             0                             0                             0                             0                             0
 -0.1229677837291447140000E+00 -0.1226772188959260462271E+00  0.7434901642611595473653E+00 -0.1345299061428178455380E+00  0.9437168922604080023575E+00  0.3021591163866515494796E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           190                             0                             0                             0                             0                             0                             0
 -0.1372539370067403230458E+00 -0.1226772188959260462271E+00  0.7366760186913707819656E+00 -0.1501593238755969950127E+00  0.9437168922604080023575E+00  0.2947042665377971326635E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           191                             0                             0                             0                             0                             0                             0
 -0.1511638867834046440208E+00 -0.1226772188959260462271E+00  0.7291235321784463874195E+00 -0.1653771653390797569116E+00  0.9437168922604078913352E+00  0.2864416527790050182034E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           192                             0                             0                             0                             0                             0                             0
 -0.1646595068536686745642E+00 -0.1226772188959260462271E+00  0.7208534055629516323904E+00 -0.1801417194875940541721E+00  0.9437168922604077803129E+00  0.2773939223602607251351E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           193                             0                             0                             0                             0                             0                             0
 -0.1777038066609887279057E+00 -0.1226772188959260462271E+00  0.7118883066870898002065E+00 -0.1944125177044901398027E+00  0.9437168922604078913352E+00  0.2675858744817422030238E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           194                             0                             0                             0                             0                             0                             0
 -0.1902610326862911593881E+00 -0.1226772188959260462271E+00  0.7022528082637234936314E+00 -0.2081504447238066435322E+00  0.9437168922604080023575E+00  0.2570443923209353442871E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           195                             0                             0                             0                             0                             0                             0
 -0.2022967664458827641294E+00 -0.1226772188959260462271E+00  0.6919733205242757367870E+00 -0.2213178458424952810280E+00  0.9437168922604080023575E+00  0.2457983693477133191330E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           196                             0                             0                             0                             0                             0                             0
 -0.2137780188301219574942E+00 -0.1226772188959260462271E+00  0.6810780188301219784108E+00 -0.2338786301293444280791E+00  0.9437168922604080023575E+00  0.2338786301293444558347E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           197                             0                             0                             0                             0                             0                             0
 -0.2246733205242756603592E+00 -0.1226772188959260462271E+00  0.6695967664458828405571E+00 -0.2457983693477132358662E+00  0.9437168922604077803129E+00  0.2213178458424953365391E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           198                             0                             0                             0                             0                             0                             0
 -0.2349528082637234172037E+00 -0.1226772188959260462271E+00  0.6575610326862912913271E+00 -0.2570443923209352332648E+00  0.9437168922604081133798E+00  0.2081504447238067823100E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           199                             0                             0                             0                             0                             0                             0
 -0.2445883066870897792899E+00 -0.1226772188959260462271E+00  0.6450038066609887765779E+00 -0.2675858744817422030238E+00  0.9437168922604080023575E+00  0.1944125177044902230694E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           200                             0                             0                             0                             0                             0                             0
 -0.2535534055629516392294E+00 -0.1226772188959260462271E+00  0.6319595068536686399696E+00 -0.2773939223602608361574E+00  0.9437168922604080023575E+00  0.1801417194875940264165E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                           201                             0                             0                             0                             0                             0                             0
 -0.2618235321784463942585E+00 -0.1226772188959260462271E+00  0.6184638867834048037153E+00 -0.2864416527790049071811E+00  0.9437168922604080023575E+00  0.1653771653390799512007E+00
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
