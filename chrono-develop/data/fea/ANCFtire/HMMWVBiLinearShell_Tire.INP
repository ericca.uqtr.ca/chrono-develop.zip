 NumFlexBodys
              1
 SYSPR [NumElems, NumElemsX, NumElemsY, Node]
           2880            120             24           3000
 ELEMN [#ofElem, ETYPE, LayID, IC / EL(m), EW(m)]
                             1                             1                             1                             1                             2                           121                           122
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                             2                             1                             1                             2                             3                           122                           123
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                             3                             1                             1                             3                             4                           123                           124
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                             4                             1                             1                             4                             5                           124                           125
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                             5                             1                             1                             5                             6                           125                           126
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                             6                             1                             1                             6                             7                           126                           127
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                             7                             1                             1                             7                             8                           127                           128
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                             8                             1                             1                             8                             9                           128                           129
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                             9                             1                             1                             9                            10                           129                           130
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            10                             1                             1                            10                            11                           130                           131
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            11                             1                             1                            11                            12                           131                           132
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            12                             1                             1                            12                            13                           132                           133
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            13                             1                             1                            13                            14                           133                           134
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            14                             1                             1                            14                            15                           134                           135
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            15                             1                             1                            15                            16                           135                           136
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            16                             1                             1                            16                            17                           136                           137
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            17                             1                             1                            17                            18                           137                           138
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            18                             1                             1                            18                            19                           138                           139
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            19                             1                             1                            19                            20                           139                           140
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            20                             1                             1                            20                            21                           140                           141
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            21                             1                             1                            21                            22                           141                           142
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            22                             1                             1                            22                            23                           142                           143
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            23                             1                             1                            23                            24                           143                           144
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            24                             1                             1                            24                            25                           144                           145
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            25                             1                             1                            25                            26                           145                           146
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            26                             1                             1                            26                            27                           146                           147
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            27                             1                             1                            27                            28                           147                           148
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            28                             1                             1                            28                            29                           148                           149
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            29                             1                             1                            29                            30                           149                           150
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            30                             1                             1                            30                            31                           150                           151
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            31                             1                             1                            31                            32                           151                           152
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            32                             1                             1                            32                            33                           152                           153
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            33                             1                             1                            33                            34                           153                           154
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            34                             1                             1                            34                            35                           154                           155
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            35                             1                             1                            35                            36                           155                           156
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            36                             1                             1                            36                            37                           156                           157
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            37                             1                             1                            37                            38                           157                           158
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            38                             1                             1                            38                            39                           158                           159
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            39                             1                             1                            39                            40                           159                           160
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            40                             1                             1                            40                            41                           160                           161
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            41                             1                             1                            41                            42                           161                           162
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            42                             1                             1                            42                            43                           162                           163
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            43                             1                             1                            43                            44                           163                           164
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            44                             1                             1                            44                            45                           164                           165
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            45                             1                             1                            45                            46                           165                           166
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            46                             1                             1                            46                            47                           166                           167
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            47                             1                             1                            47                            48                           167                           168
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            48                             1                             1                            48                            49                           168                           169
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            49                             1                             1                            49                            50                           169                           170
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            50                             1                             1                            50                            51                           170                           171
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            51                             1                             1                            51                            52                           171                           172
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            52                             1                             1                            52                            53                           172                           173
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            53                             1                             1                            53                            54                           173                           174
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            54                             1                             1                            54                            55                           174                           175
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            55                             1                             1                            55                            56                           175                           176
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            56                             1                             1                            56                            57                           176                           177
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            57                             1                             1                            57                            58                           177                           178
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            58                             1                             1                            58                            59                           178                           179
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            59                             1                             1                            59                            60                           179                           180
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            60                             1                             1                            60                            61                           180                           181
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            61                             1                             1                            61                            62                           181                           182
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            62                             1                             1                            62                            63                           182                           183
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            63                             1                             1                            63                            64                           183                           184
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            64                             1                             1                            64                            65                           184                           185
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            65                             1                             1                            65                            66                           185                           186
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            66                             1                             1                            66                            67                           186                           187
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            67                             1                             1                            67                            68                           187                           188
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            68                             1                             1                            68                            69                           188                           189
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            69                             1                             1                            69                            70                           189                           190
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            70                             1                             1                            70                            71                           190                           191
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            71                             1                             1                            71                            72                           191                           192
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            72                             1                             1                            72                            73                           192                           193
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            73                             1                             1                            73                            74                           193                           194
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            74                             1                             1                            74                            75                           194                           195
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            75                             1                             1                            75                            76                           195                           196
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            76                             1                             1                            76                            77                           196                           197
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            77                             1                             1                            77                            78                           197                           198
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            78                             1                             1                            78                            79                           198                           199
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            79                             1                             1                            79                            80                           199                           200
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            80                             1                             1                            80                            81                           200                           201
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            81                             1                             1                            81                            82                           201                           202
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            82                             1                             1                            82                            83                           202                           203
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            83                             1                             1                            83                            84                           203                           204
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            84                             1                             1                            84                            85                           204                           205
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            85                             1                             1                            85                            86                           205                           206
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            86                             1                             1                            86                            87                           206                           207
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            87                             1                             1                            87                            88                           207                           208
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            88                             1                             1                            88                            89                           208                           209
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            89                             1                             1                            89                            90                           209                           210
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            90                             1                             1                            90                            91                           210                           211
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            91                             1                             1                            91                            92                           211                           212
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            92                             1                             1                            92                            93                           212                           213
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            93                             1                             1                            93                            94                           213                           214
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            94                             1                             1                            94                            95                           214                           215
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            95                             1                             1                            95                            96                           215                           216
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            96                             1                             1                            96                            97                           216                           217
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            97                             1                             1                            97                            98                           217                           218
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            98                             1                             1                            98                            99                           218                           219
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                            99                             1                             1                            99                           100                           219                           220
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           100                             1                             1                           100                           101                           220                           221
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           101                             1                             1                           101                           102                           221                           222
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           102                             1                             1                           102                           103                           222                           223
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           103                             1                             1                           103                           104                           223                           224
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           104                             1                             1                           104                           105                           224                           225
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           105                             1                             1                           105                           106                           225                           226
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           106                             1                             1                           106                           107                           226                           227
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           107                             1                             1                           107                           108                           227                           228
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           108                             1                             1                           108                           109                           228                           229
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           109                             1                             1                           109                           110                           229                           230
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           110                             1                             1                           110                           111                           230                           231
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           111                             1                             1                           111                           112                           231                           232
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           112                             1                             1                           112                           113                           232                           233
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           113                             1                             1                           113                           114                           233                           234
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           114                             1                             1                           114                           115                           234                           235
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           115                             1                             1                           115                           116                           235                           236
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           116                             1                             1                           116                           117                           236                           237
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           117                             1                             1                           117                           118                           237                           238
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           118                             1                             1                           118                           119                           238                           239
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           119                             1                             1                           119                           120                           239                           240
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           120                             1                             1                           120                             1                           240                           121
  0.1493900017809823496662E-01  0.3488307704159736982730E-01
                           121                             1                             1                           121                           122                           241                           242
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           122                             1                             1                           122                           123                           242                           243
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           123                             1                             1                           123                           124                           243                           244
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           124                             1                             1                           124                           125                           244                           245
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           125                             1                             1                           125                           126                           245                           246
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           126                             1                             1                           126                           127                           246                           247
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           127                             1                             1                           127                           128                           247                           248
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           128                             1                             1                           128                           129                           248                           249
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           129                             1                             1                           129                           130                           249                           250
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           130                             1                             1                           130                           131                           250                           251
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           131                             1                             1                           131                           132                           251                           252
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           132                             1                             1                           132                           133                           252                           253
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           133                             1                             1                           133                           134                           253                           254
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           134                             1                             1                           134                           135                           254                           255
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           135                             1                             1                           135                           136                           255                           256
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           136                             1                             1                           136                           137                           256                           257
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           137                             1                             1                           137                           138                           257                           258
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           138                             1                             1                           138                           139                           258                           259
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           139                             1                             1                           139                           140                           259                           260
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           140                             1                             1                           140                           141                           260                           261
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           141                             1                             1                           141                           142                           261                           262
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           142                             1                             1                           142                           143                           262                           263
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           143                             1                             1                           143                           144                           263                           264
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           144                             1                             1                           144                           145                           264                           265
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           145                             1                             1                           145                           146                           265                           266
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           146                             1                             1                           146                           147                           266                           267
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           147                             1                             1                           147                           148                           267                           268
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           148                             1                             1                           148                           149                           268                           269
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           149                             1                             1                           149                           150                           269                           270
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           150                             1                             1                           150                           151                           270                           271
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           151                             1                             1                           151                           152                           271                           272
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           152                             1                             1                           152                           153                           272                           273
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           153                             1                             1                           153                           154                           273                           274
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           154                             1                             1                           154                           155                           274                           275
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           155                             1                             1                           155                           156                           275                           276
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           156                             1                             1                           156                           157                           276                           277
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           157                             1                             1                           157                           158                           277                           278
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           158                             1                             1                           158                           159                           278                           279
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           159                             1                             1                           159                           160                           279                           280
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           160                             1                             1                           160                           161                           280                           281
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           161                             1                             1                           161                           162                           281                           282
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           162                             1                             1                           162                           163                           282                           283
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           163                             1                             1                           163                           164                           283                           284
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           164                             1                             1                           164                           165                           284                           285
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           165                             1                             1                           165                           166                           285                           286
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           166                             1                             1                           166                           167                           286                           287
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           167                             1                             1                           167                           168                           287                           288
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           168                             1                             1                           168                           169                           288                           289
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           169                             1                             1                           169                           170                           289                           290
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           170                             1                             1                           170                           171                           290                           291
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           171                             1                             1                           171                           172                           291                           292
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           172                             1                             1                           172                           173                           292                           293
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           173                             1                             1                           173                           174                           293                           294
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           174                             1                             1                           174                           175                           294                           295
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           175                             1                             1                           175                           176                           295                           296
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           176                             1                             1                           176                           177                           296                           297
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           177                             1                             1                           177                           178                           297                           298
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           178                             1                             1                           178                           179                           298                           299
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           179                             1                             1                           179                           180                           299                           300
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           180                             1                             1                           180                           181                           300                           301
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           181                             1                             1                           181                           182                           301                           302
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           182                             1                             1                           182                           183                           302                           303
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           183                             1                             1                           183                           184                           303                           304
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           184                             1                             1                           184                           185                           304                           305
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           185                             1                             1                           185                           186                           305                           306
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           186                             1                             1                           186                           187                           306                           307
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           187                             1                             1                           187                           188                           307                           308
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           188                             1                             1                           188                           189                           308                           309
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           189                             1                             1                           189                           190                           309                           310
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           190                             1                             1                           190                           191                           310                           311
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           191                             1                             1                           191                           192                           311                           312
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           192                             1                             1                           192                           193                           312                           313
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           193                             1                             1                           193                           194                           313                           314
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           194                             1                             1                           194                           195                           314                           315
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           195                             1                             1                           195                           196                           315                           316
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           196                             1                             1                           196                           197                           316                           317
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           197                             1                             1                           197                           198                           317                           318
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           198                             1                             1                           198                           199                           318                           319
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           199                             1                             1                           199                           200                           319                           320
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           200                             1                             1                           200                           201                           320                           321
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           201                             1                             1                           201                           202                           321                           322
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           202                             1                             1                           202                           203                           322                           323
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           203                             1                             1                           203                           204                           323                           324
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           204                             1                             1                           204                           205                           324                           325
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           205                             1                             1                           205                           206                           325                           326
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           206                             1                             1                           206                           207                           326                           327
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           207                             1                             1                           207                           208                           327                           328
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           208                             1                             1                           208                           209                           328                           329
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           209                             1                             1                           209                           210                           329                           330
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           210                             1                             1                           210                           211                           330                           331
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           211                             1                             1                           211                           212                           331                           332
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           212                             1                             1                           212                           213                           332                           333
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           213                             1                             1                           213                           214                           333                           334
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           214                             1                             1                           214                           215                           334                           335
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           215                             1                             1                           215                           216                           335                           336
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           216                             1                             1                           216                           217                           336                           337
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           217                             1                             1                           217                           218                           337                           338
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           218                             1                             1                           218                           219                           338                           339
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           219                             1                             1                           219                           220                           339                           340
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           220                             1                             1                           220                           221                           340                           341
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           221                             1                             1                           221                           222                           341                           342
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           222                             1                             1                           222                           223                           342                           343
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           223                             1                             1                           223                           224                           343                           344
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           224                             1                             1                           224                           225                           344                           345
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           225                             1                             1                           225                           226                           345                           346
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           226                             1                             1                           226                           227                           346                           347
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           227                             1                             1                           227                           228                           347                           348
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           228                             1                             1                           228                           229                           348                           349
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           229                             1                             1                           229                           230                           349                           350
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           230                             1                             1                           230                           231                           350                           351
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           231                             1                             1                           231                           232                           351                           352
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           232                             1                             1                           232                           233                           352                           353
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           233                             1                             1                           233                           234                           353                           354
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           234                             1                             1                           234                           235                           354                           355
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           235                             1                             1                           235                           236                           355                           356
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           236                             1                             1                           236                           237                           356                           357
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           237                             1                             1                           237                           238                           357                           358
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           238                             1                             1                           238                           239                           358                           359
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           239                             1                             1                           239                           240                           359                           360
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           240                             1                             1                           240                           121                           360                           241
  0.1672069257892352250883E-01  0.3634531937081487279473E-01
                           241                             1                             2                           241                           242                           361                           362
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           242                             1                             2                           242                           243                           362                           363
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           243                             1                             2                           243                           244                           363                           364
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           244                             1                             2                           244                           245                           364                           365
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           245                             1                             2                           245                           246                           365                           366
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           246                             1                             2                           246                           247                           366                           367
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           247                             1                             2                           247                           248                           367                           368
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           248                             1                             2                           248                           249                           368                           369
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           249                             1                             2                           249                           250                           369                           370
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           250                             1                             2                           250                           251                           370                           371
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           251                             1                             2                           251                           252                           371                           372
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           252                             1                             2                           252                           253                           372                           373
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           253                             1                             2                           253                           254                           373                           374
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           254                             1                             2                           254                           255                           374                           375
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           255                             1                             2                           255                           256                           375                           376
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           256                             1                             2                           256                           257                           376                           377
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           257                             1                             2                           257                           258                           377                           378
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           258                             1                             2                           258                           259                           378                           379
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           259                             1                             2                           259                           260                           379                           380
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           260                             1                             2                           260                           261                           380                           381
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           261                             1                             2                           261                           262                           381                           382
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           262                             1                             2                           262                           263                           382                           383
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           263                             1                             2                           263                           264                           383                           384
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           264                             1                             2                           264                           265                           384                           385
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           265                             1                             2                           265                           266                           385                           386
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           266                             1                             2                           266                           267                           386                           387
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           267                             1                             2                           267                           268                           387                           388
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           268                             1                             2                           268                           269                           388                           389
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           269                             1                             2                           269                           270                           389                           390
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           270                             1                             2                           270                           271                           390                           391
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           271                             1                             2                           271                           272                           391                           392
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           272                             1                             2                           272                           273                           392                           393
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           273                             1                             2                           273                           274                           393                           394
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           274                             1                             2                           274                           275                           394                           395
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           275                             1                             2                           275                           276                           395                           396
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           276                             1                             2                           276                           277                           396                           397
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           277                             1                             2                           277                           278                           397                           398
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           278                             1                             2                           278                           279                           398                           399
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           279                             1                             2                           279                           280                           399                           400
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           280                             1                             2                           280                           281                           400                           401
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           281                             1                             2                           281                           282                           401                           402
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           282                             1                             2                           282                           283                           402                           403
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           283                             1                             2                           283                           284                           403                           404
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           284                             1                             2                           284                           285                           404                           405
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           285                             1                             2                           285                           286                           405                           406
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           286                             1                             2                           286                           287                           406                           407
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           287                             1                             2                           287                           288                           407                           408
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           288                             1                             2                           288                           289                           408                           409
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           289                             1                             2                           289                           290                           409                           410
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           290                             1                             2                           290                           291                           410                           411
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           291                             1                             2                           291                           292                           411                           412
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           292                             1                             2                           292                           293                           412                           413
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           293                             1                             2                           293                           294                           413                           414
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           294                             1                             2                           294                           295                           414                           415
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           295                             1                             2                           295                           296                           415                           416
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           296                             1                             2                           296                           297                           416                           417
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           297                             1                             2                           297                           298                           417                           418
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           298                             1                             2                           298                           299                           418                           419
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           299                             1                             2                           299                           300                           419                           420
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           300                             1                             2                           300                           301                           420                           421
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           301                             1                             2                           301                           302                           421                           422
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           302                             1                             2                           302                           303                           422                           423
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           303                             1                             2                           303                           304                           423                           424
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           304                             1                             2                           304                           305                           424                           425
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           305                             1                             2                           305                           306                           425                           426
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           306                             1                             2                           306                           307                           426                           427
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           307                             1                             2                           307                           308                           427                           428
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           308                             1                             2                           308                           309                           428                           429
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           309                             1                             2                           309                           310                           429                           430
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           310                             1                             2                           310                           311                           430                           431
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           311                             1                             2                           311                           312                           431                           432
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           312                             1                             2                           312                           313                           432                           433
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           313                             1                             2                           313                           314                           433                           434
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           314                             1                             2                           314                           315                           434                           435
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           315                             1                             2                           315                           316                           435                           436
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           316                             1                             2                           316                           317                           436                           437
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           317                             1                             2                           317                           318                           437                           438
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           318                             1                             2                           318                           319                           438                           439
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           319                             1                             2                           319                           320                           439                           440
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           320                             1                             2                           320                           321                           440                           441
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           321                             1                             2                           321                           322                           441                           442
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           322                             1                             2                           322                           323                           442                           443
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           323                             1                             2                           323                           324                           443                           444
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           324                             1                             2                           324                           325                           444                           445
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           325                             1                             2                           325                           326                           445                           446
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           326                             1                             2                           326                           327                           446                           447
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           327                             1                             2                           327                           328                           447                           448
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           328                             1                             2                           328                           329                           448                           449
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           329                             1                             2                           329                           330                           449                           450
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           330                             1                             2                           330                           331                           450                           451
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           331                             1                             2                           331                           332                           451                           452
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           332                             1                             2                           332                           333                           452                           453
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           333                             1                             2                           333                           334                           453                           454
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           334                             1                             2                           334                           335                           454                           455
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           335                             1                             2                           335                           336                           455                           456
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           336                             1                             2                           336                           337                           456                           457
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           337                             1                             2                           337                           338                           457                           458
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           338                             1                             2                           338                           339                           458                           459
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           339                             1                             2                           339                           340                           459                           460
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           340                             1                             2                           340                           341                           460                           461
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           341                             1                             2                           341                           342                           461                           462
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           342                             1                             2                           342                           343                           462                           463
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           343                             1                             2                           343                           344                           463                           464
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           344                             1                             2                           344                           345                           464                           465
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           345                             1                             2                           345                           346                           465                           466
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           346                             1                             2                           346                           347                           466                           467
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           347                             1                             2                           347                           348                           467                           468
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           348                             1                             2                           348                           349                           468                           469
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           349                             1                             2                           349                           350                           469                           470
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           350                             1                             2                           350                           351                           470                           471
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           351                             1                             2                           351                           352                           471                           472
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           352                             1                             2                           352                           353                           472                           473
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           353                             1                             2                           353                           354                           473                           474
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           354                             1                             2                           354                           355                           474                           475
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           355                             1                             2                           355                           356                           475                           476
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           356                             1                             2                           356                           357                           476                           477
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           357                             1                             2                           357                           358                           477                           478
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           358                             1                             2                           358                           359                           478                           479
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           359                             1                             2                           359                           360                           479                           480
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           360                             1                             2                           360                           241                           480                           361
  0.1850222097176387747730E-01  0.3547263962464578673783E-01
                           361                             1                             2                           361                           362                           481                           482
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           362                             1                             2                           362                           363                           482                           483
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           363                             1                             2                           363                           364                           483                           484
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           364                             1                             2                           364                           365                           484                           485
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           365                             1                             2                           365                           366                           485                           486
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           366                             1                             2                           366                           367                           486                           487
  0.2029307227361165644197E-01  0.3467957737943610369014E-01
                           367                             1                             2                           367                           368                           487                           488
