 -0.1341499999999998804512E+00  0.1150000000000000049960E+00  0.2349453841646350626959E+00 -0.2897175232833381491870E-01 -0.9983198637050665347203E+00 -0.5018054701697612779432E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2992                             0                             0                             0                             0                             0                             0
 -0.1218056510801204250782E+00  0.1150000000000000049960E+00  0.2282429495602609215155E+00 -0.2630580063574132140825E-01 -0.9983198637050664236980E+00 -0.5162804068342996544061E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2993                             0                             0                             0                             0                             0                             0
 -0.1091274413372371604458E+00  0.1150000000000000049960E+00  0.2221957537144901573267E+00 -0.2356774657209999984664E-01 -0.9983198637050665347203E+00 -0.5293402547899164756195E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2994                             0                             0                             0                             0                             0                             0
 -0.9615012086300417371021E-01  0.1150000000000000049960E+00  0.2168203715708008072482E+00 -0.2076509495327857543479E-01 -0.9983198637050665347203E+00 -0.5409492179011439472180E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2995                             0                             0                             0                             0                             0                             0
 -0.8290925959079842311183E-01  0.1150000000000000049960E+00  0.2121315366780103239819E+00 -0.1790552765255422340562E-01 -0.9983198637050665347203E+00 -0.5510754768070236231381E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2996                             0                             0                             0                             0                             0                             0
 -0.6944114980100628276016E-01  0.1150000000000000049960E+00  0.2081421008066429712002E+00 -0.1499688254513218375885E-01 -0.9983198637050665347203E+00 -0.5596912761357619725544E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2997                             0                             0                             0                             0                             0                             0
 -0.5578270664640471582230E-01  0.1150000000000000049960E+00  0.2048629987231199711673E+00 -0.1204713202507446366540E-01 -0.9983198637050664236980E+00 -0.5667730005802758264100E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2998                             0                             0                             0                             0                             0                             0
 -0.4197136697029398705316E-01  0.1150000000000000049960E+00  0.2023032182183245875073E+00 -0.9064361153521943367806E-02 -0.9983198637050664236980E+00 -0.5723012396261072110004E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          2999                             0                             0                             0                             0                             0                             0
 -0.2804498669471139349341E-01  0.1150000000000000049960E+00  0.2004697754726922354074E+00 -0.6056745498103588420946E-02 -0.9983198637050666457426E+00 -0.5762608407542951088898E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
                          3000                             0                             0                             0                             0                             0                             0
 -0.1404173705998195721689E-01  0.1150000000000000049960E+00  0.1993676958253478570526E+00 -0.3032528724274198821814E-02 -0.9983198637050665347203E+00 -0.5786409509733751732607E-01
  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00  0.0000000000000000000000E+00
 LayPROP [Layup#, #ofLayer / Layerheight, PlyAngle, Material_ID]
              1              3
  0.5000000E-03  0.9000000E+02              1
  0.5000000E-02  0.0000000E+00              3
  0.5000000E-03  0.9000000E+02              1
              2              3
  0.5000000E-03  0.9000000E+02              1
  0.1000000E-03  0.0000000E+00              3
  0.5000000E-03  0.9000000E+02              1
              3              4
  0.5000000E-03  0.9000000E+02              1
  0.3000000E-03  0.2000000E+02              2
  0.3000000E-03  -0.200000E+02              2
  0.1000000E-02  0.0000000E+00              3
 MPROP [#ofMat, Mtype / Dense[kg/m3], H(m), E(Pa)/ nu, G(Pa)]
              1              2
  0.1000000E+04  0.7560000E+10  0.4740000E+08  0.4740000E+08
  0.4500000E+00  0.4500000E+00  0.4500000E+00  0.1634483E+08  0.1634483E+08  0.1634483E+08
              2              2
  0.2639000E+04  0.1800000E+12  0.4740000E+08  0.4740000E+08
  0.4500000E+00  0.4500000E+00  0.4500000E+00  0.1634483E+08  0.1634483E+08  0.1634483E+08
              3              2
  0.1100000E+04  0.4740000E+08  0.4740000E+08  0.4740000E+08
  0.4500000E+00  0.4500000E+00  0.4500000E+00  0.1634483E+08  0.1634483E+08  0.1634483E+08
              4              2
  0.1000000E+04  0.7560000E+10  0.4740000E+08  0.4740000E+08
  0.4500000E+00  0.4500000E+00  0.4500000E+00  0.1634483E+08  0.1634483E+08  0.1634483E+08
              5              2
  0.2639000E+04  0.1800000E+12  0.4740000E+08  0.4740000E+08
  0.4500000E+00  0.4500000E+00  0.4500000E+00  0.1634483E+08  0.1634483E+08  0.1634483E+08
              6              2
  0.1100000E+04  0.4740000E+08  0.4740000E+08  0.4740000E+08
  0.4500000E+00  0.4500000E+00  0.4500000E+00  0.1634483E+08  0.1634483E+08  0.1634483E+08
              7              2
  0.1000000E+04  0.6592500E+10  0.4740000E+08  0.4740000E+08
  0.4500000E+00  0.4500000E+00  0.4500000E+00  0.1634483E+08  0.1634483E+08  0.1634483E+08
