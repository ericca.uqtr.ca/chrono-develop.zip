** Output from COS2ABQ translator version 2010
*HEADING

** PARTS
**
*PART,NAME=PART1
*NODE, NSET=NSET1
1,-.1104936004,0.5751289129,-.2582403719
2,-.3987055644E-01,0.6298547983,-.6404489279E-01
3,0.7171866600E-03,0.6292254329,-.7346724719E-01
4,0.2380023361E-03,0.6208315492,-.1260571033
5,-.9543947130E-01,0.6156882048,-.1391710490
6,-.9543947130E-01,0.5821447968,-.2440245003
7,-.2094821185,0.5664156675,-.2388503253
8,-.2403514534,0.5334894657,-.2497312725
9,-.2545000613,0.4996226132,-.2643168569
10,-.2546792626,0.4771024883,-.3022801876
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG1
1,3093,3094,268,1516,12825,12826,12827,12828,12829,9749
2,3093,1509,3095,262,12830,12831,12832,12833,12834,12835
3,3093,3094,261,268,12825,12836,12837,12827,12826,12838
4,333,445,3096,1363,9190,12839,12840,9191,4396,12841
5,3096,3097,327,1355,12842,12843,12844,12845,12846,12847
6,3096,3098,326,333,12848,12849,12850,12840,12851,12852
7,3099,1455,481,475,12853,4596,12854,12855,9572,9575
8,3099,3100,481,288,12856,12857,12854,12858,12859,4555
9,481,294,1455,3099,9525,9526,4596,12854,12860,12853
10,3101,3102,185,1694,12861,12862,12863,12864,12865,5114
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*ORIENTATION,NAME=RECT1,DEFINITION=COORDINATES,SYSTEM=RECTANGULAR
1.0,0.0,0.0,0.0,1.0,0.0
0.0,0.0,0.0
*SOLID SECTION,ELSET=PART1_EG1,MATERIAL=MAT1, ORIENT=RECT1
*END PART
** ASSEMBLY
*ASSEMBLY, NAME=ASSEMBLY
*INSTANCE, NAME=PART1-1, PART=PART1
*END INSTANCE
*NSET,NSET=BC_SURF,INSTANCE=PART1-1
751,752,753,754,755,756,757,758,759,760,761,762,763,764,765,766,
767,768,769,770,771,772,773,774,775,776,777,778,779,780,781,782,
783,784,785,786,787,788,789,790,791,792,793,794,795,796,797,798,
799,800,801,802,803,804,805,806,807,808,809,810,811,812,813,814,
815,816,817,818,819,820,821,822,823,824,825,826,827,828,829,830,
831,832,833,834,835,836,837,838,839,840,841,842,843,844,845,846,
847,848,849,850,851,852,853,854,855,856,857,858,859,860,861,862,
2106,2107,2108,2109,2110,2111,2112,2113,2114,2115,2116,2117,2118,2119,2120,2121,
2122,2123,2124,2125,2126,2127,2128,2129,2130,2131,2132,2133,2134,2135,2136,2137,
2138,2139,2948,2949,2950,2951,2952,2953,2954,2955,2956,2957,2958,2959,2960,2961,
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*NSET,NSET=BC_RIMTIRE,INSTANCE=PART1-1
2140,2141,2142,2143,2144,2145,2146,2147,2148,2149,2150,2151,2152,2153,2154,2155,
2156,2157,2158,2159,2160,2161,2162,2163,2164,2165,2166,2167,2168,2169,2170,2171,
2172,2173,2174,2175,2176,2177,2178,6078,6079,6080,6081,6082,6083,6084,6085,6086,
6087,6088,6089,6090,6091,6092,6093,6094,6095,6096,6097,6098,6099,6100,6101,6102,
6103,6104,6105,6106,6107,6108,6109,6110,6111,6112,6113,6114,6115,6116,12059,12060,
12061,12062,12063,12064,12065,12066,12067,12068,12069,12070,12071,12072,12073,12074,12075,12076,
12077,12078,12079,12080,12081,12082,12083,12084,12085,12086,12087,12088,12089,12090,12091,12092,
12093,12094,12095,12096,12097,12098,12099,12100,12101,12102,12103,12104,12105,12106,12107,12108,
12109,12110,12111,12112,12113,12114,12115,12116,12117,12118,12119,12120,12121,12122,12123,12124,
12125,12126,12127,12128,12129,12130,12131,
*END ASSEMBLY
*MATERIAL,NAME=MAT1
*ELASTIC
0.610000E+07,0.490000E+00,
*PLASTIC
0.92374E+07,0.0000,0.0000
*EXPANSION
0.670000E-03,
*DENSITY
0.100000E+04,
*CONDUCTIVITY
0.140000E+00,
*STEP,SOLVER=ITERATIVE
LOAD CASE NUMBER 1
*STATIC
*BOUNDARY
ASSEMBLY.BC_SURF,1,1
ASSEMBLY.BC_SURF,2,2
ASSEMBLY.BC_SURF,3,3
ASSEMBLY.BC_RIMTIRE,3,3
*END STEP
