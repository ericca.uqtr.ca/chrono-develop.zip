Read_Cap_hardening_parameter_table
100
0	358000
0.01	421414.1971
0.02	496061.2444
0.03	583930.8688
0.04	687365.2465
0.05	809121.4342
0.06	952444.8591
0.07	1121155.826
0.08	1319751.347
0.09	1553525.011
0.1	1828708.087
0.11	2152635.616
0.12	2533941.926
0.13	2982790.789
0.14	3511146.328
0.15	4133091.929
0.16	4865205.633
0.17	5727002.027
0.18	6741452.405
0.19	7935597.074
0.2	9341266.115
0.21	10995927.82
0.22	12943687.41
0.23	15236462.68
0.24	17935367.84
0.25	21112342.56
0.26	24852069.52
0.27	29254231.63
0.28	34436169.09
0.29	40536007.12
0.3	47716337.69
0.31	56168553.45
0.32	66117949.31
0.33	77829727.72
0.34	91616067.64
0.35	107844445.8
0.36	126947431.6
0.37	149434217.8
0.38	175904192.5
0.39	207062916.3
0.4	243740929.1
0.41	286915888.1
0.42	337738627.5
0.43	397563833.9
0.44	467986156
0.45	550882710
0.46	648463114.3
0.47	763328387.3
0.48	898540277.8
0.49	1057702876
0.5	1245058683
0.51	1465601690
0.52	1725210501
0.53	2030805023
0.54	2390530917
0.55	2813976723
0.56	3312429446
0.57	3899175406
0.58	4589854394
0.59	5402876548
0.6	6359913079
0.61	7486473921
0.62	8812587700
0.63	10373602150
0.64	12211126316
0.65	14374139643
0.66	16920297532
0.67	19917468154
0.68	23445541481
0.69	27598558766
0.7	32487219228
0.71	38241830744
0.72	45015783236
0.73	52989637287
0.74	62375937016
0.75	73424875462
0.76	86430963518
0.77	1.01741E+11
0.78	1.19763E+11
0.79	1.40977E+11
0.8	1.65949E+11
0.81	1.95344E+11
0.82	2.29946E+11
0.83	2.70678E+11
0.84	3.18624E+11
0.85	3.75063E+11
0.86	4.415E+11
0.87	5.19705E+11
0.88	6.11763E+11
0.89	7.20127E+11
0.9	8.47686E+11
0.91	9.97841E+11
0.92	1.17459E+12
0.93	1.38265E+12
0.94	1.62757E+12
0.95	1.91587E+12
0.96	2.25524E+12
0.97	2.65472E+12
0.98	3.12496E+12
0.99	3.6785E+12
