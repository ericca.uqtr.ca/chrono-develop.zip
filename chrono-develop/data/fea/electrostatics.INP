** Output from COS2ABQ translator version 2011
*HEADING

** PARTS
**
*PART,NAME=PART1
*NODE, NSET=NSET1
1,-.8126591891E-01,0.7820817083E-01,0.7000000030E-01
2,-.8126591891E-01,0.6017285958E-01,0.7000000030E-01
3,-.8126591891E-01,0.4213754833E-01,0.7000000030E-01
4,-.8126591891E-01,0.2410223708E-01,0.7000000030E-01
5,-.8126591891E-01,0.6066924427E-02,0.7000000030E-01
6,-.8126591891E-01,-.1196838729E-01,0.7000000030E-01
7,-.8126591891E-01,-.3000370041E-01,0.7000000030E-01
8,-.8126591891E-01,-.4803901166E-01,0.7000000030E-01
9,-.8126591891E-01,-.6607432663E-01,0.7000000030E-01
10,-.6334862113E-01,-.6607432663E-01,0.7000000030E-01
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*ELEMENT,TYPE=DC3D10,ELSET=PART1_EG1
1,1268,1269,1270,1271,24950,24937,24949,24948,24936,24922
2,1268,1272,1269,1273,24947,24935,24950,24946,24897,24934
3,1268,1270,1272,1274,24949,24921,24947,24945,24920,24896
4,1275,1276,1277,1278,24868,24855,24867,24866,24854,24841
5,1279,1280,1276,1281,24812,24852,24853,24811,24799,24851
6,1279,1282,1283,1276,24810,24774,24809,24853,24850,24849
7,1280,1284,1285,1279,24798,24755,24797,24812,24808,24807
8,1279,1283,1286,1278,24809,24762,24806,24827,24826,24825
9,1279,1276,1277,1281,24853,24855,24840,24811,24851,24839
10,1279,1286,1287,1277,24806,24734,24805,24840,24838,24837
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*SOLID SECTION,ELSET=PART1_EG1,MATERIAL=MAT1
*END PART
** ASSEMBLY
*ASSEMBLY, NAME=ASSEMBLY
*INSTANCE, NAME=PART1-1, PART=PART1
*END INSTANCE
*NSET,NSET=IMPV1,INSTANCE=PART1-1
451,452,453,454,455,456,457,458,459,460,461,462,463,464,465,466
467,468,469,470,471,472,473,474,475,476,477,478,479,480,481,482
483,484,485,486,487,488,489,490,491,492,493,494,495,496,497,498
499,500,501,502,503,504,505,506,507,508,509,510,511,512,513,514
515,516,517,518,519,520,521,522,523,524,525,526,527,528,529,530
531,532,533,534,535,536,537,538,539,540,541,542,543,544,545,546
547,548,549,550,551,552,553,554,555,556,557,558,559,560,561,562
563,564,565,566,567,568,569,570,571,572,573,574,575,576,577,578
579,580,581,582,583,584,585,586,587,588,589,590,591,592,593,594
595,596,597,598,599,600,601,602,603,604,605,606,607,608,609,610
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*NSET,NSET=IMPV2,INSTANCE=PART1-1
1120,1121,1122,1123,1124,1125,1126,1127,1128,1129,1130,1131,1132,1133,1134,1135
1136,1137,1138,1139,1140,1141,1142,1143,1144,1145,1146,1147,1148,1149,1150,1151
1152,1153,1154,1155,1156,1157,1158,1159,1160,1161,1162,1163,1164,1165,1166,1167
1168,1169,1170,1171,1172,1173,1174,1175,1176,1177,1178,1179,1180,1181,1182,1183
1184,1185,1186,1187,1188,1189,1190,1191,1192,1193,1194,1195,1196,1197,1198,1199
1200,1201,1202,1203,1204,1205,1206,1207,1208,1209,1210,1211,1212,1213,1214,1215
1216,1217,1218,1219,1220,1221,1222,1223,1224,1225,1226,1227,1228,1229,1230,1231
1232,1233,1234,1235,1236,1237,1238,1239,1240,1241,1242,1243,1244,1245,1246,1247
1248,1249,1250,1251,1252,1253,1254,1255,1256,1257,1258,1259,1260,1261,1262,1263
1264,1265,1266,1267,24960,24965,24971,24976,24981,24984,24988,24994,24995,24996,25002,25003
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*END ASSEMBLY
*MATERIAL,NAME=MAT1
*ELASTIC
0.210000E+12,0.280000E+00,
*PLASTIC
0.62042E+09,0.0000,0.0000
*EXPANSION
0.130000E-04,
*DENSITY
0.770000E+04,
*CONDUCTIVITY
0.500000E+02,
*SPECIFIC HEAT
0.460000E+03,
** PHYSICAL CONSTANTS
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0.0000000, STEFAN BOLTZMANN=0.56703001E-07
*STEP,solver=DDM
LOAD CASE NUMBER 1
*HEAT TRANSFER,STEADY STATE
1.0000,0.0000,
*BOUNDARY,OP=NEW
IMPV1,11,11,0.200000E+01
*BOUNDARY,OP=NEW
IMPV2,11,11,0.230000E+02
*END STEP
